Properties of the parts of a building model (IFC2X3), part 3 of 8

# IfcFlowFitting: AI_Raccord cdc_Coude montant:standaard (27)
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Raccord cdc_Coude montant:standaard:...) | Center to End (mm) | Niveau | Élévation par rapport au niveau (mm) | Angle (deg) | Radius (mm) | Rayon de courbure (mm) | Taille | Tray Height (mm) | Tray Width (mm) | Volume (m3) | Type de service
863303 | 13.8406 | RDC | 2743.86 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
863323 | 13.8406 | RDC | 2743.86 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
905958 | 13.8406 | RDC | 2621.39 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | CF
905960 | 13.8406 | RDC | 2621.39 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | CF
906000 | 13.8406 | RDC | 2621.39 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
906002 | 13.8406 | RDC | 2621.39 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
906398 | 13.8406 | RDC | 2703.71 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
906424 | 13.8406 | RDC | 2703.71 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | CF
906459 | 13.8406 | RDC | 2703.71 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | CF
906486 | 13.8406 | RDC | 2703.71 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
906684 | 13.8406 | RDC | 2470 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | CF
978126 | 151 | R-1 | 2517.76 | 90 | 150 | 150 | 300 mmx100 mmø-300 mmx100 mmø | 100 | 300 | 0.00712854 | CF | Données d'identification - AI_Phase: EXISTANT
978239 | 151 | R-1 | 2517.76 | 90 | 150 | 150 | 300 mmx100 mmø-300 mmx100 mmø | 100 | 300 | 0.00712854 | CF | Données d'identification - AI_Phase: EXISTANT
1156756 | 13.8406 | RDC | 2743.86 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1156766 | 13.8406 | RDC | 2743.86 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1157593 | 13.8406 | RDC | 2743.86 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1157595 | 13.8406 | RDC | 2743.86 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1158034 | 13.8406 | RDC | 2743.86 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | cfa
1158036 | 13.8406 | RDC | 2743.86 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | cfa
1159462 | 13.8406 | RDC | 2729.72 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | cfa
1159475 | 13.8406 | RDC | 2729.72 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | cfa
1177293 | 13.8406 | RDC | 2743.86 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1177295 | 13.8406 | RDC | 2743.86 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1211013 | 22.1249 | R-1 | 2352.76 | 45 | 150 | 51 | 200 mmx100 mmø-200 mmx100 mmø | 100 | 200 | 0.000841069 | CF
1223201 | 22.1249 | R-1 | 2352.76 | 45 | 150 | 51 | 200 mmx100 mmø-200 mmx100 mmø | 100 | 200 | 0.000841069 | CF
1223210 | 151 | R-1 | 2517.76 | 90 | 150 | 150 | 200 mmx100 mmø-200 mmx100 mmø | 100 | 200 | 0.00475236 | CF
1227964 | 22.1249 | R-1 | 2350 | 45 | 150 | 51 | 200 mmx100 mmø-200 mmx100 mmø | 100 | 200 | 0.000841069 | CF

# IfcFlowFitting: AI_Raccord cdc_Té:150mm Radius (5)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de chemins de câbles; Nom de la famille: AI_Raccord cdc_Té
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Radius: 150 mm
Type - Données d'identification - Nom du type: 150mm Radius; Numéro OmniClass: 23.80.30.17.17; Sous-projet: Famille : Raccords de chemins de câbles : AI_Raccord cdc_Té; Titre OmniClass: Cable Trays and Horizontal Racks
Pset_DistributionFlowElementCommon - Reference: 150mm Radius; sets with these values: 2
Autre - Famille: AI_Raccord cdc_Té; Famille et type: AI_Raccord cdc_Té: 150mm Radius; ID du type: 804237; Radius Label: 150 mm; Radius Label 1: 152.54 mm; Type: 150mm Radius
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 2857 mm
Cotes - Epaisseur: 2.54 mm; Tray Height: 60 mm; Tray Length: 75 mm; Tray Width 1: 200 mm
Graphismes - Utiliser l'échelle d'annotations: no
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Raccord cdc_Té:150mm Radius:...) | Taille | Tray Width 3 (mm) | Volume (m3) | Type de service
861470 | 200 mmx60 mmø-200 mmx60 mmø-200 mmx60 mmø | 200 | 0.0110795 | CF
1156590 | 200 mmx60 mmø-200 mmx60 mmø-100 mmx60 mmø | 100 | 0.00852951 | cfa
1157588 | 200 mmx60 mmø-200 mmx60 mmø-100 mmx60 mmø | 100 | 0.00852951 | cfa
1158029 | 200 mmx60 mmø-200 mmx60 mmø-100 mmx60 mmø | 100 | 0.00852951 | CF
1177288 | 200 mmx60 mmø-200 mmx60 mmø-100 mmx60 mmø | 100 | 0.00852951 | cfa

# IfcFlowFitting: Chapeau - Générique:Standard (3)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de canalisation; Nom de la famille: Chapeau - Générique; Nom de la table de consultation: Cap - Generic
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Sous-projet: Famille : Raccords de canalisation : Chapeau - Générique
Type - Génie climatique - Méthode de perte de charge: Non défini
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Chapeau - Générique; Famille et type: Chapeau - Générique: Standard; ID du type: 639784; Rayon extérieur du raccord: 57.15 mm
Cotes - Diamètre extérieur du raccord: 114.3 mm; Diamètre nominal: 100 mm; Hauteur: 64 mm; Rayon nominal: 50 mm; Taille: 100 mmø; Taille maximale: 100 mm; Taille minimale: 100 mm; Volume: 0.000656662 m3
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 03_PLB
Génie climatique - Classification du système: Sanitaire
Génie climatique - Débit - Perte de pression: 0 Pa
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 100 mmø
Name (Chapeau - Générique:Standard:...) | Niveau | Élévation par rapport au niveau (mm) | Type de système | Abréviation du système | Nom du système = Group
946012 | R-1 | 2416.1 | 3.Eaux Usées | EU | EU 2 | Données d'identification - AI_Phase: EXISTANT
1212980 | RDC | 382.113 | 3.Eaux Vannes | EV | EV 4
1220331 | R-1 | 2543.3 | 3.Unitaire | U | U 2

# IfcFlowFitting: Chemin de câbles - Union:Standard (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de chemins de câbles; Nom de la famille: Chemin de câbles - Union
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Sous-projet: Famille : Raccords de chemins de câbles : Chemin de câbles - Union
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Chemin de câbles - Union; Famille et type: Chemin de câbles - Union: Standard; ID du type: 804275
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 2857 mm
Cotes - Epaisseur: 2.54 mm; h: 60 mm; l: 200 mm; Longueur de chemin: 80 mm; Taille: 200 mmx60 mmø-200 mmx60 mmø; Volume: 0.00096 m3
Graphismes - Utiliser l'échelle d'annotations: no
Données d'identification - Sous-projet: 02_ELE; Type de service: CF
Phase de construction - Phase de création: Nouvelle construction
Name (Chemin de câbles - Union:Standard:...)
1157189
1157316

# IfcFlowFitting: Coude - FF - PVC-U:Standard (53)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de canalisation; Nom de la famille: Coude - FF - PVC-U; Nom de la table de consultation: Elbow - FF - PVC-U
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Sous-projet: Famille : Raccords de canalisation : Coude - FF - PVC-U
Type - Génie climatique - Méthode de perte de charge: Non défini
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Coude - FF - PVC-U; Famille et type: Coude - FF - PVC-U: Standard; ID du type: 804525; IsCustom: no
Graphismes - Utiliser l'échelle d'annotations: yes
Génie climatique - Classification du système: Sanitaire
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Name (Coude - FF - PVC-U:Standard:...) | Angle 1 (deg) | Centre à prise introuvable (mm) | Longueur de la prise introuvable (mm) = Longueur de la prise (mm) | Rayon du centre (mm) | Rayon extérieur de la prise (mm) | Niveau | Élévation par rapport au niveau (mm) | Angle (deg) | Centre à prise (mm) | Diamètre extérieur de la prise (mm) | Diamètre extérieur du raccord (mm) = Diamètre nominal (mm) = Taille maximale (mm) = Taille minimale (mm) | Epaisseur de la paroi (mm) | Rayon nominal (mm) | Taille = Taille globale | Taille de la coche (mm) | Volume (m3) | Sous-projet | Type de système | Abréviation du système | Nom du système | Group | Perte de pression (Pa)
943370 | 67.5 | 53.4 | 57 | 95.632 | 52.3 | R-1 | 2416.05 | 57.9911 | 53 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00173973 | 03_PLB | 3.Eaux Vannes | EV | EV 1 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943375 | 87.5 | 74.9 | 57 | 77.015 | 52.3 | R-1 | 2312.78 | 89.9889 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00192957 | 03_PLB | 3.Eaux Vannes | EV | EV 1 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943380 | 20 | 16.5 | 57 | 151.932 | 52.3 | R-1 | 2246.79 | 14.9983 | 20 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.0012919 | 03_PLB | 3.Eaux Vannes | EV | EV 1 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943389 | 87.5 | 74.9 | 57 | 78.1637 | 52.3 | R-1 | 2421.59 | 89.1406 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00193464 | 03_PLB | 3.Eaux Vannes | EV | EV 1 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943394 | 20 | 16.5 | 57 | 190.309 | 52.3 | R-1 | 2122.26 | 11.9986 | 20 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00129255 | 03_PLB | 3.Eaux Vannes | EV | EV 1 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943532 | 87.5 | 74.9 | 57 | 78.1637 | 52.3 | R-1 | 2050.97 | 89.1406 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00193464 | 03_PLB | 3.Eaux Vannes | EV | EV 1 | EV 1 | Données d'identification - AI_Phase: EXISTANT
945741 | 20 | 16.5 | 57 | 190.309 | 52.3 | R-1 | 2104.03 | 11.9986 | 20 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00129255 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945745 | 20 | 16.5 | 57 | 151.934 | 52.3 | R-1 | 2230.61 | 14.9981 | 20 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.0012919 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945750 | 87.5 | 74.9 | 57 | 77.0173 | 52.3 | R-1 | 2289.11 | 89.9871 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00192958 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945760 | 87.5 | 33.42 | 23 | 25.0049 | 18 | R-1 | 2441.41 | 89.9889 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000784046 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945768 | 87.5 | 74.9 | 57 | 78.1637 | 52.3 | R-1 | 2033.33 | 89.1406 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00193464 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946039 | 87.5 | 33.42 | 23 | 25.3778 | 18 | R-1 | 2493.46 | 89.1406 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785735 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946221 | 87.5 | 33.42 | 23 | 24.9224 | 18 | R-1 | 2412.85 | 90.1782 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000783667 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946565 | 87.5 | 33.42 | 23 | 25.374 | 18 | RDC | -487.672 | 89.1493 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785717 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946608 | 87.5 | 33.42 | 23 | 25.3778 | 18 | R-1 | 2487.46 | 89.1406 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785735 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946815 | 45 | 12.78 | 23 | 36.0934 | 18 | R-1 | 2456.86 | 33.8987 | 11 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000639927 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946842 | 87.5 | 33.42 | 23 | 25.3867 | 18 | RDC | -409.417 | 89.1207 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785774 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
947460 | 45 | 12.78 | 23 | 27.1268 | 18 | R-1 | 2464.41 | 44.1455 | 11 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000636281 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
947626 | 87.5 | 33.42 | 23 | 25.3778 | 18 | R-1 | 2484.72 | 89.1406 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785735 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
947631 | 87.5 | 33.42 | 23 | 25.7647 | 18 | R-1 | 2478.86 | 88.274 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000787441 | 03_PLB | 3.Eaux Usées | EU | EU 2 | EU 2 | Données d'identification - AI_Phase: EXISTANT
1218450 | 87.5 | 33.42 | 23 | 25.3778 | 18 | RDC | 2402.25 | 89.1406 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785735 | 03_PLB | 3.Eaux Usées | EU | EU 5 | EU 5; EU 18 | 0
1218512 | 87.5 | 33.42 | 23 | 25.379 | 18 | RDC | 2704.42 | 89.138 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.000078574 | 01_CVC | 3.Condensats | EU | EU 4 | EU 4 | 0
1218519 | 87.5 | 33.42 | 23 | 25.0056 | 18 | RDC | 2649.4 | 89.9871 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.000078405 | 01_CVC | 3.Condensats | EU | EU 4 | EU 4 | 0
1218524 | 87.5 | 33.42 | 23 | 25.379 | 18 | RDC | 2923.74 | 89.138 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.000078574 | 01_CVC | 3.Condensats | EU | EU 4 | EU 4 | 0
1218539 | 87.5 | 33.42 | 23 | 25.3778 | 18 | RDC | 2637.05 | 89.1406 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785735 | 03_PLB | 3.Eaux Usées | EU | EU 3 | EU 3; EU 4
1219381 | 87.5 | 74.9 | 57 | 96.8179 | 52.3 | R-1 | 2467.3 | 76.991 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00200131 | 03_PLB | 3.Unitaire | U | U 2 | U 2 | 0
1219672 | 45 | 32.5 | 57 | 104.663 | 52.3 | R-1 | 2467.3 | 35 | 33 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00148167 | 03_PLB | 3.Unitaire | U | U 2 | U 2 | 0
1219839 | 45 | 32.5 | 57 | 104.663 | 52.3 | R-1 | 2356.16 | 35 | 33 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00148167 | 03_PLB | 3.Unitaire | U | U 2 | U 2 | 0
1220120 | 87.5 | 74.9 | 57 | 96.8179 | 52.3 | R-1 | 2356.07 | 76.991 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00200131 | 03_PLB | 3.Unitaire | U | U 2 | U 2 | 0
1220308 | 87.5 | 44.4 | 32 | 38.986 | 27 | RDC | -359.499 | 90.0205 | 39 | 54 | 50 | 2 | 25 | 50 mmø-50 mmø | 20 | 0.000266835 | 03_PLB | 3.Eaux Usées | EU | EU 8 | EU 8 | 0
1220552 | 87.5 | 33.42 | 23 | 24.9429 | 18 | RDC | -371.542 | 90.1311 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000783761 | 03_PLB | 3.Eaux Usées | EU | EU 6 | EU 6 | 0
1220772 | 87.5 | 74.9 | 57 | 76.6931 | 52.3 | RDC | -392.362 | 90.2288 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00192812 | 03_PLB | 3.Eaux Vannes | EV | EV 4 | EV 4 | 0
1220997 | 87.5 | 33.42 | 23 | 25.2519 | 18 | RDC | -253.575 | 89.4257 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785169 | 03_PLB | 3.Eaux Usées | EU | EU 19 | EU 19
1221022 | 45 | 12.78 | 23 | 26.9365 | 18 | RDC | -265.833 | 44.4271 | 11 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000636167 | 03_PLB | 3.Eaux Usées | EU | EU 19 | EU 19
1221175 | 87.5 | 33.42 | 23 | 25 | 18 | RDC | -364.687 | 90 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000784024 | 03_PLB | 3.Eaux Usées | EU | EU 3 | EU 3 | 0
1221464 | 87.5 | 33.42 | 23 | 25.0314 | 18 | RDC | -411.699 | 89.928 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000784168 | 03_PLB | 3.Eaux Usées | EU | EU 7 | EU 7 | 0
1221629 | 87.5 | 44.4 | 32 | 39.1461 | 27 | RDC | -425.968 | 89.7857 | 39 | 54 | 50 | 2 | 25 | 50 mmø-50 mmø | 20 | 0.000267014 | 03_PLB | 3.Eaux Usées | EU | EU 9 | EU 9 | 0
1221851 | 87.5 | 74.9 | 57 | 77.0077 | 52.3 | R-1 | 2486.94 | 89.9943 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00192953 | 03_PLB | 3.Unitaire | U | U 1 | U 1 | 0
1222053 | 45 | 32.5 | 57 | 106.517 | 52.3 | R-1 | 2484.34 | 34.4271 | 33 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.0014822 | 03_PLB | 3.Unitaire | U | U 1 | U 1 | 0
1222069 | 45 | 32.5 | 57 | 106.517 | 52.3 | R-1 | 2362.6 | 34.4271 | 33 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.0014822 | 03_PLB | 3.Unitaire | U | U 1 | U 1 | 0
1222073 | 87.5 | 74.9 | 57 | 77.0077 | 52.3 | R-1 | 2359.15 | 89.9943 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00192953 | 03_PLB | 3.Unitaire | U | U 1 | U 1 | 0
1222233 | 87.5 | 33.42 | 23 | 25.0192 | 18 | RDC | -337.621 | 89.956 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000784112 | 03_PLB | 3.Eaux Usées | EU | EU 10 | EU 10 | 0
1222339 | 87.5 | 74.9 | 57 | 76.8511 | 52.3 | RDC | -358.934 | 90.1109 | 77 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00192883 | 03_PLB | 3.Eaux Vannes | EV | EV 2 | EV 2 | 0
1222517 | 87.5 | 33.42 | 23 | 24.9993 | 18 | RDC | -361.549 | 90.0017 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.000078402 | 03_PLB | 3.Eaux Usées | EU | EU 5 | EU 5 | 0
1222725 | 87.5 | 33.42 | 23 | 25.2514 | 18 | RDC | -260.215 | 89.4267 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785167 | 03_PLB | 3.Eaux Usées | EU | EU 11 | EU 11 | 0
1222729 | 87.5 | 33.42 | 23 | 25.2512 | 18 | RDC | -275.424 | 89.4271 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785167 | 03_PLB | 3.Eaux Usées | EU | EU 11 | EU 11 | 0
1223504 | 87.5 | 33.42 | 23 | 24.9996 | 18 | RDC | 395.622 | 90.0009 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000784022 | 03_PLB | 3.Eaux Usées | EU | EU 19 | EU 19
1223569 | 67.5 | 17.36 | 23 | 38.144 | 18 | RDC | -391.803 | 50.5249 | 18 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000738698 | 03_PLB | 3.Eaux Usées | EU | EU 19 | EU 19
1223631 | 30 | 22 | 57 | 101.785 | 52.3 | R-1 | 2508.42 | 26.0012 | 23.5 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00134232 | 03_PLB | 3.Unitaire | U | U 2 | U 2
1223915 | 30 | 22 | 57 | 88.3221 | 52.3 | R-1 | 2322.28 | 29.7992 | 23.5 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.00134032 | 03_PLB | 3.Unitaire | U | U 2 | U 2 | 0
1224052 | 30 | 22 | 57 | 99.298 | 52.3 | R-1 | 2321.95 | 26.6295 | 23.5 | 104.6 | 100 | 2.3 | 50 | 100 mmø-100 mmø | 40 | 0.001342 | 03_PLB | 3.Unitaire | U | U 1 | U 1 | 0
1226863 | 87.5 | 33.42 | 23 | 25.2512 | 18 | RDC | -264.62 | 89.4271 | 25 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000785167 | 03_PLB | 3.Eaux Usées | EU | EU 16 | EU 16 | 0
1226909 | 45 | 12.78 | 23 | 36.7701 | 18 | RDC | -289.626 | 33.3098 | 11 | 36 | 32 | 2 | 16 | 32 mmø-32 mmø | 12.8 | 0.0000640107 | 03_PLB | 3.Eaux Usées | EU | EU 16 | EU 16 | 0

# IfcFlowFitting: Coude - Générique1:Standard (156)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de canalisation; Nom de la famille: Coude - Générique1; Nom de la table de consultation: Elbow - Generic
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Sous-projet: Famille : Raccords de canalisation : Coude - Générique1
Type - Génie climatique - Méthode de perte de charge: Coefficient K à partir du tableau; Tableau de coefficient K: Regular 45, 90 and 180 Elbow
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Coude - Générique1; Famille et type: Coude - Générique1: Standard; ID du type: 805767
Graphismes - Utiliser l'échelle d'annotations: yes
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Name (Coude - Générique1:Standard:...) | Libellé de centre à extrémité (mm) = Centre à extrémité (mm) | Rayon du centre (mm) | Rayon extérieur du raccord (mm) | Niveau | Élévation par rapport au niveau (mm) | Angle (deg) | Diamètre extérieur du raccord (mm) | Diamètre nominal (mm) = Taille maximale (mm) = Taille minimale (mm) | Rayon nominal (mm) | Taille = Taille globale | Taille de la coche (mm) | Volume (m3) | Sous-projet | Type de système | Abréviation du système | Classification du système | Nom du système = Group | Trajectoire critique | Perte de pression (Pa)
841520 | 32 | 77.2548 | 21.1 | RDC | 2918.3 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
841524 | 32 | 77.2548 | 21.1 | RDC | 2856.7 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
841528 | 32 | 77.2548 | 21.1 | RDC | 2856.7 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
842649 | 32 | 77.2548 | 21.1 | RDC | 2856.7 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
842653 | 32 | 77.2548 | 21.1 | RDC | 2856.7 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
843804 | 32 | 40.2301 | 21.1 | RDC | 2918.3 | 76.9992 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000756161 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844160 | 32 | 32 | 21.1 | RDC | 2730 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844168 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844170 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844193 | 32 | 32 | 21.1 | RDC | 2730 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844201 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844203 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844228 | 32 | 32 | 21.1 | RDC | 2730 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844257 | 32 | 32 | 21.1 | RDC | 2730 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844446 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844477 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
844481 | 32 | 77.2548 | 21.1 | RDC | 2918.3 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
883833 | 32 | 77.2548 | 21.1 | RDC | 2856.73 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
883837 | 32 | 77.2548 | 21.1 | RDC | 2856.73 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
884053 | 32 | 32 | 21.1 | RDC | 2730 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
884059 | 32 | 32 | 21.1 | RDC | 2730 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
884065 | 32 | 32 | 21.1 | RDC | 2730 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
884069 | 32 | 32 | 21.1 | RDC | 2730 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
884110 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
884129 | 32 | 77.2548 | 21.1 | RDC | 2918.3 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
884133 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
884141 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
884143 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
936931 | 18.9117 | 18.9117 | 11.25 | RDC | 1134.98 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 1 |  | 0
936945 | 18.9117 | 18.9117 | 11.25 | RDC | 1134.98 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 1 |  | 0
936953 | 18.9117 | 18.9117 | 11.25 | RDC | 2752.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 1 |  | 0
937019 | 18.9117 | 18.9117 | 11.25 | RDC | 2752.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 1 |  | 0
937489 | 18.9117 | 18.9117 | 11.25 | RDC | 2752.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 1 |  | 0
937491 | 18.9117 | 18.9117 | 11.25 | RDC | 2752.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 1 |  | 0
937604 | 18.9117 | 18.9117 | 11.25 | RDC | 296.697 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 3 |  | 0
937906 | 18.9117 | 18.9117 | 11.25 | RDC | 296.697 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 3 |  | 0
938284 | 18.9117 | 18.9117 | 11.25 | RDC | 1134.98 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 2 |  | 0
938288 | 18.9117 | 18.9117 | 11.25 | RDC | 1134.98 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 2 |  | 0
938290 | 18.9117 | 18.9117 | 11.25 | RDC | 2752.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 2 |  | 0
938296 | 18.9117 | 18.9117 | 11.25 | RDC | 2752.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 2 |  | 0
938330 | 18.9117 | 18.9117 | 11.25 | RDC | 2752.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 2 |  | 0
938332 | 18.9117 | 18.9117 | 11.25 | RDC | 2752.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 2 |  | 0
940391 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0 | Données d'identification - AI_Phase: EXISTANT
940397 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0 | Données d'identification - AI_Phase: EXISTANT
940428 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0 | Données d'identification - AI_Phase: EXISTANT
940459 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0 | Données d'identification - AI_Phase: EXISTANT
948310 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948312 | 18.9117 | 18.9117 | 11.25 | RDC | 237.308 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948316 | 18.9117 | 18.9117 | 11.25 | RDC | 237.308 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948401 | 18.9117 | 18.9117 | 11.25 | RDC | 1134.98 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1 |  | 0
948405 | 18.9117 | 18.9117 | 11.25 | RDC | 1134.98 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1 |  | 0
948407 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1 |  | 0
948419 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948423 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948425 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948436 | 18.9117 | 18.9117 | 11.25 | RDC | 237.303 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948588 | 18.9117 | 18.9117 | 11.25 | RDC | 1134.98 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1 |  | 0
948592 | 18.9117 | 18.9117 | 11.25 | RDC | 1134.98 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1 |  | 0
948594 | 18.9117 | 18.9117 | 11.25 | RDC | 2602.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1 |  | 0
948606 | 18.9117 | 18.9117 | 11.25 | RDC | 2602.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948610 | 18.9117 | 18.9117 | 11.25 | RDC | 2602.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948612 | 18.9117 | 18.9117 | 11.25 | RDC | 2602.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948882 | 25 | 25 | 16.7 | R-1 | 2360.72 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1065503 | 32 | 32.0072 | 21.1 | RDC | 2869.97 | 89.9871 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703084 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 12 | Données d'identification - AI_Métré canalisation: EAU GLACEE
1065971 | 32 | 77.2507 | 21.1 | RDC | 2866.44 | 45.0022 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848613 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 12 | Données d'identification - AI_Métré canalisation: EAU GLACEE
1066156 | 32 | 32.0072 | 21.1 | RDC | 2843.37 | 89.9871 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703084 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 13 | Données d'identification - AI_Métré canalisation: EAU GLACEE
1066396 | 32 | 32.0072 | 21.1 | RDC | 2821.94 | 89.9871 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703084 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 14 | Données d'identification - AI_Métré canalisation: FRIGO
1066400 | 32 | 32.0072 | 21.1 | RDC | 2885.67 | 89.9871 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703084 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 14 | Données d'identification - AI_Métré canalisation: FRIGO
1066408 | 32 | 32.0072 | 21.1 | RDC | 2817.68 | 89.9871 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703084 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 14 | Données d'identification - AI_Métré canalisation: FRIGO
1066591 | 32 | 32.0072 | 21.1 | RDC | 2783.93 | 89.9871 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703084 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 15 | Données d'identification - AI_Métré canalisation: FRIGO
1066599 | 32 | 32.0072 | 21.1 | RDC | 2785.79 | 89.9871 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703084 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 15 | Données d'identification - AI_Métré canalisation: FRIGO
1066603 | 32 | 32.0072 | 21.1 | RDC | 2849.51 | 89.9871 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703084 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 15 | Données d'identification - AI_Métré canalisation: FRIGO
1067398 | 32 | 32.0032 | 21.1 | RDC | 2875.41 | 89.9943 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703052 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 17 | Données d'identification - AI_Métré canalisation: EAU GLACEE
1067839 | 32 | 77.2603 | 21.1 | RDC | 2876.21 | 44.9971 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848623 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 17 | Données d'identification - AI_Métré canalisation: EAU GLACEE
1156494 | 32 | 32 | 21.1 | RDC | 2730 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1156505 | 32 | 32.0038 | 21.1 | RDC | 2918.24 | 89.9932 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703057 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1156507 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1156530 | 32 | 32 | 21.1 | RDC | 2730 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1156538 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1156540 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1200000 | 32 | 77.2548 | 21.1 | RDC | 2918.3 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1200002 | 32 | 111.6 | 21.1 | RDC | 2918.3 | 31.9992 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000871719 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1203871 | 25 | 25 | 16.7 | R-1 | 2133.82 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1203875 | 25 | 25 | 16.7 | R-1 | 2133.82 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1203877 | 25 | 25 | 16.7 | R-1 | 2133.82 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1203879 | 25 | 25 | 16.7 | R-1 | 2133.82 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1203924 | 25 | 25 | 16.7 | R-1 | 2133.82 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1203936 | 25 | 25 | 16.7 | R-1 | 2603.3 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1203959 | 25 | 25 | 16.7 | R-1 | 2133.82 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1203971 | 25 | 25 | 16.7 | R-1 | 2603.3 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1203998 | 25 | 25 | 16.7 | R-1 | 2133.82 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1204010 | 25 | 25 | 16.7 | R-1 | 2603.3 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1204035 | 25 | 25 | 16.7 | R-1 | 2133.82 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1204047 | 25 | 25 | 16.7 | R-1 | 2603.3 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1215681 | 18.9117 | 18.912 | 11.25 | RDC | 550.702 | 89.9991 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1 |  | 0
1215716 | 18.9117 | 18.9117 | 11.25 | RDC | 550.7 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1215992 | 18.9117 | 18.9113 | 11.25 | RDC | 550.691 | 90.0011 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118111 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1216005 | 18.9117 | 18.9117 | 11.25 | RDC | 458.58 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1216009 | 18.9117 | 18.911 | 11.25 | RDC | 458.58 | 90.0022 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.000011811 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1216122 | 18.9117 | 18.9117 | 11.25 | RDC | 550.7 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1216131 | 18.9117 | 18.9117 | 11.25 | RDC | 550.694 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1217510 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0 | Données d'identification - AI_Métré canalisation: SERVEUR
1217611 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0 | Données d'identification - AI_Métré canalisation: SERVEUR
1217628 | 25 | 60.3553 | 16.7 | RDC | 2717.09 | 45 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000415308 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1217668 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0 | Données d'identification - AI_Métré canalisation: SERVEUR
1217681 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1217741 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0 | Données d'identification - AI_Métré canalisation: SERVEUR
1217754 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1218189 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1218216 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1218273 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1218281 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1218310 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1218320 | 25 | 25 | 16.7 | RDC | 2717.09 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1218847 | 25 | 25 | 16.7 | RDC | -296.699 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1218851 | 25 | 31.4348 | 16.7 | R-1 | 2603.3 | 76.9903 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000370077 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1218881 | 25 | 31.4314 | 16.7 | R-1 | 2603.3 | 76.9962 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000370066 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1218898 | 25 | 25 | 16.7 | RDC | -296.699 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1218902 | 25 | 25 | 16.7 | R-1 | 2603.3 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1218927 | 25 | 31.4347 | 16.7 | R-1 | 2603.3 | 76.9904 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000370076 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1218943 | 25 | 25 | 16.7 | RDC | -296.699 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1218947 | 25 | 25 | 16.7 | R-1 | 2603.3 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 4 | no | 0
1218970 | 25 | 31.4347 | 16.7 | R-1 | 2603.3 | 76.9905 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000370076 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1218986 | 25 | 25 | 16.7 | RDC | -296.699 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1218993 | 25 | 24.6355 | 16.7 | R-1 | 2603.3 | 90.8415 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.000034221 | 01_CVC | 0.Liaison frigorifique | FR | Alimentation hydraulique | FR 3 | no | 0
1222944 | 25 | 25 | 16.7 | RDC | -296.699 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1222968 | 25 | 25 | 16.7 | R-1 | 2603.3 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1225260 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1225293 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1225363 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1225371 | 18.9117 | 18.9117 | 11.25 | RDC | 877.089 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1225666 | 25 | 25 | 16.7 | RDC | 333.408 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1225851 | 18.9117 | 18.9117 | 11.25 | RDC | 533.408 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1225885 | 18.9117 | 18.9117 | 11.25 | RDC | 2602.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1225918 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1225951 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1225997 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1226040 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1226072 | 18.9117 | 18.9117 | 11.25 | RDC | 550.694 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1 |  | 0
1226711 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 3
1226754 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 3
1226788 | 18.9117 | 18.9117 | 11.25 | RDC | 2717.09 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 3
1228275 | 25 | 25 | 16.7 | R-1 | 2360.72 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1228277 | 25 | 25 | 16.7 | R-1 | 2603.3 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1228281 | 25 | 25 | 16.7 | R-1 | 2603.3 | 90 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø | 13.36 | 0.0000344056 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1229352 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1229404 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1229430 | 32 | 77.2548 | 21.1 | RDC | 2856.73 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1229499 | 32 | 32.0005 | 21.1 | RDC | 2918.3 | 89.9992 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.000070303 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1229523 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1229570 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1229613 | 32 | 77.2548 | 21.1 | RDC | 2856.73 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1229621 | 32 | 32 | 21.1 | RDC | 2918.3 | 90 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000703026 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1229623 | 32 | 77.2548 | 21.1 | RDC | 2918.3 | 45 | 42.2 | 32 | 16 | 32 mmø-32 mmø | 16.88 | 0.0000848617 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | no | 0
1237861 | 18.9117 | 18.9117 | 11.25 | RDC | 2393.46 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 1 |  | 0
1237878 | 18.9117 | 18.9117 | 11.25 | RDC | 2393.46 | 90 | 22.5 | 20 | 10 | 20 mmø-20 mmø | 9 | 0.0000118112 | 03_PLB | 2.Eau Chaude Sanitaire | EC | Eau chaude sanitaire | EC 1 |  | 0

# IfcFlowFitting: Coude circulaire:1 D (44)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de gaine; Nom de la famille: Coude circulaire
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Multiplicateur de rayon: 1
Type - Données d'identification - Nom du type: 1 D; Numéro OmniClass: 23.75.70.14; Sous-projet: Famille : Raccords de gaine : Coude circulaire; Titre OmniClass: Air Ductwork
Pset_DistributionFlowElementCommon - Reference: 1 D; sets with these values: 2
Autre - Famille: Coude circulaire; Famille et type: Coude circulaire: 1 D; ID du type: 804594; Type: 1 D
Contraintes - Niveau: RDC
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 01_CVC
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Revêtement - Epaisseur du revêtement: 0 mm
Name (Coude circulaire:1 D:...) | Élévation par rapport au niveau (mm) | Angle (deg) | Longueur1 (mm) | Rayon de la gaine (mm) | Rayon du centre (mm) | Taille | Volume (m3) | Type de système | Abréviation du système | Classification du système | Nom du système = Group | Taille globale = Taille libre
875008 | 2645.21 | 45 | 51.7767 | 62.5 | 125 | 125ø-125ø | 0.00120473 | 0.Soufflage | S | Soufflage | S 1 | 125 mmø-125 mmø
875184 | 2645.21 | 45 | 51.7767 | 62.5 | 125 | 125ø-125ø | 0.00120473 | 0.Soufflage | S | Soufflage | S 1 | 125 mmø-125 mmø
875202 | 2645.21 | 45 | 51.7767 | 62.5 | 125 | 125ø-125ø | 0.00120473 | 0.Soufflage | S | Soufflage | S 1 | 125 mmø-125 mmø
875224 | 2645.21 | 45 | 51.7767 | 62.5 | 125 | 125ø-125ø | 0.00120473 | 0.Soufflage | S | Soufflage | S 1 | 125 mmø-125 mmø
875242 | 2645.21 | 45 | 51.7767 | 62.5 | 125 | 125ø-125ø | 0.00120473 | 0.Soufflage | S | Soufflage | S 1 | 125 mmø-125 mmø
877762 | 2820 | 90 | 125 | 62.5 | 125 | 125ø-125ø | 0.00240949 | 0.Soufflage | S | Soufflage | S 1 | 125 mmø-125 mmø
882045 | 2825 | 90 | 250 | 125 | 250 | 250ø-250ø | 0.019276 | 0.Soufflage | S | Soufflage | S 2 | 250 mmø-250 mmø
883195 | 2820 | 90 | 250 | 125 | 250 | 250ø-250ø | 0.019276 | 0.Soufflage | S | Soufflage | S 1 | 250 mmø-250 mmø
883509 | 2820 | 90 | 250 | 125 | 250 | 250ø-250ø | 0.019276 | 0.Soufflage | S | Soufflage | S 1 | 250 mmø-250 mmø
883511 | 2820 | 90 | 250 | 125 | 250 | 250ø-250ø | 0.019276 | 0.Soufflage | S | Soufflage | S 1 | 250 mmø-250 mmø
923942 | 2618.47 | 90 | 125 | 62.5 | 125 | 125ø-125ø | 0.00240949 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 2 | 125 mmø-125 mmø
924656 | 2518 | 45 | 82.8427 | 100 | 200 | 200ø-200ø | 0.00493458 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-200 mmø
924660 | 2518 | 12.9919 | 22.7729 | 100 | 200 | 200ø-200ø | 0.00142465 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-200 mmø
926336 | 2518 | 45 | 82.8427 | 100 | 200 | 200ø-200ø | 0.00493458 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-200 mmø
926346 | 2860.82 | 45 | 82.8427 | 100 | 200 | 200ø-200ø | 0.00493458 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-200 mmø
926737 | 2860.82 | 45 | 82.8427 | 100 | 200 | 200ø-200ø | 0.00493458 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-200 mmø
940610 | 2809.9 | 90 | 250 | 125 | 250 | 250ø-250ø | 0.019276 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 250 mmø-250 mmø | Données d'identification - AI_Phase: EXISTANT
940719 | 2809.9 | 90 | 250 | 125 | 250 | 250ø-250ø | 0.019276 | 0.Soufflage | S | Soufflage | S 6 | 250 mmø-250 mmø | Données d'identification - AI_Phase: EXISTANT
940740 | 2809.9 | 90.0001 | 250 | 125 | 250 | 250ø-250ø | 0.019276 | 0.Soufflage | S | Soufflage | S 6 | 250 mmø-250 mmø | Données d'identification - AI_Phase: EXISTANT
940775 | 2809.9 | 90 | 250 | 125 | 250 | 250ø-250ø | 0.019276 | 0.Soufflage | S | Soufflage | S 7 | 250 mmø-250 mmø | Données d'identification - AI_Phase: EXISTANT
941694 | 2809.9 | 90.021 | 250.092 | 125 | 250 | 250ø-250ø | 0.0192805 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 250 mmø-250 mmø | Données d'identification - AI_Phase: EXISTANT
942055 | 2809.9 | 89.9996 | 249.998 | 125 | 250 | 250ø-250ø | 0.0192759 | 0.Soufflage | S | Soufflage | S 7 | 250 mmø-250 mmø | Données d'identification - AI_Phase: EXISTANT
942243 | 2809.9 | 15 | 26.3305 | 100 | 200 | 200ø-200ø | 0.00164485 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-200 mmø | Données d'identification - AI_Phase: EXISTANT
942305 | 2860.82 | 15 | 26.3305 | 100 | 200 | 200ø-200ø | 0.00164485 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-200 mmø | Données d'identification - AI_Phase: EXISTANT
1067654 | 2800 | 30 | 53.5898 | 100 | 200 | 200ø-200ø | 0.00328971 | 0.Soufflage | S | Soufflage | S 4 | 200 mmø-200 mmø
1067688 | 2720 | 30 | 53.5898 | 100 | 200 | 200ø-200ø | 0.00328971 | 0.Soufflage | S | Soufflage | S 4 | 200 mmø-200 mmø
1067692 | 2720 | 30 | 53.5898 | 100 | 200 | 200ø-200ø | 0.00328971 | 0.Soufflage | S | Soufflage | S 4 | 200 mmø-200 mmø
1067724 | 2800 | 30 | 53.5898 | 100 | 200 | 200ø-200ø | 0.00328971 | 0.Soufflage | S | Soufflage | S 4 | 200 mmø-200 mmø
1155415 | 2825 | 30 | 66.9873 | 125 | 250 | 250ø-250ø | 0.00642522 | 0.Soufflage | S | Soufflage | S 2 | 250 mmø-250 mmø
1155432 | 2675 | 30 | 66.9873 | 125 | 250 | 250ø-250ø | 0.00642522 | 0.Soufflage | S | Soufflage | S 2 | 250 mmø-250 mmø
1155625 | 2675 | 25 | 69.8338 | 157.5 | 315 | 315ø-315ø | 0.0107107 | 0.Soufflage | S | Soufflage | S 4 | 315 mmø-315 mmø
1155629 | 2800 | 25 | 69.8338 | 157.5 | 315 | 315ø-315ø | 0.0107107 | 0.Soufflage | S | Soufflage | S 4 | 315 mmø-315 mmø
1200564 | 2800 | 15 | 26.3305 | 100 | 200 | 200ø-200ø | 0.00164485 | 0.Soufflage | S | Soufflage | S 4 | 200 mmø-200 mmø
1200568 | 2770 | 15 | 26.3305 | 100 | 200 | 200ø-200ø | 0.00164485 | 0.Soufflage | S | Soufflage | S 4 | 200 mmø-200 mmø
1212001 | 2675 | 90 | 250 | 125 | 250 | 250ø-250ø | 0.019276 | 0.Soufflage | S | Soufflage | S 3 | 250 mmø-250 mmø
1216430 | 2820 | 45 | 103.553 | 125 | 250 | 250ø-250ø | 0.00963785 | 0.Soufflage | S | Soufflage | S 1 | 250 mmø-250 mmø
1216440 | 2625.44 | 45 | 103.553 | 125 | 250 | 250ø-250ø | 0.00963785 | 0.Soufflage | S | Soufflage | S 1 | 250 mmø-250 mmø
1216452 | 2625.44 | 45 | 103.553 | 125 | 250 | 250ø-250ø | 0.00963785 | 0.Soufflage | S | Soufflage | S 1 | 250 mmø-250 mmø
1216466 | 2809.92 | 45 | 103.553 | 125 | 250 | 250ø-250ø | 0.00963785 | 0.Soufflage | S | Soufflage | S 1 | 250 mmø-250 mmø
1216471 | 2809.92 | 13.0004 | 28.4848 | 125 | 250 | 250ø-250ø | 0.00278434 | 0.Soufflage | S | Soufflage | S 7 | 250 mmø-250 mmø
1216640 | 2860.82 | 90 | 125 | 62.5 | 125 | 125ø-125ø | 0.00240949 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 2 | 125 mmø-125 mmø
1216757 | 2860.82 | 90 | 125 | 62.5 | 125 | 125ø-125ø | 0.00240949 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 1 | 125 mmø-125 mmø
1216867 | 2860.82 | 90 | 125 | 62.5 | 125 | 125ø-125ø | 0.00240949 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 5 | 125 mmø-125 mmø
1217160 | 2860.67 | 89.9963 | 124.992 | 62.5 | 125 | 125ø-125ø | 0.0024094 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 3 | 125 mmø-125 mmø

# IfcFlowFitting: Coude rectangulaire - Rayon:1 W (13)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de gaine; Nom de la famille: Coude rectangulaire - Rayon
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Multiplicateur de rayon: 1
Type - Données d'identification - Nom du type: 1 W; Numéro OmniClass: 23.75.70.14; Sous-projet: Famille : Raccords de gaine : Coude rectangulaire - Rayon; Titre OmniClass: Air Ductwork
Pset_DistributionFlowElementCommon - Reference: 1 W; sets with these values: 2
Autre - Famille: Coude rectangulaire - Rayon; Famille et type: Coude rectangulaire - Rayon: 1 W; ID du type: 802913; Type: 1 W
Contraintes - Niveau: RDC
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 02_ELE
Génie climatique - Type de système: 0.Goulotte; Abréviation du système: GEN; Classification du système: Soufflage
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Revêtement - Epaisseur du revêtement: 0 mm
Name (Coude rectangulaire - Rayon:1 W:...) | Élévation par rapport au niveau (mm) | Angle (deg) | Hauteur de la gaine (mm) | Largeur de la gaine (mm) = Rayon du centre (mm) | Longueur de la gaine 1 (mm) | Taille | Volume (m3) | Nom du système = Group | Taille globale = Taille libre
1156977 | 300 | 90 | 130 | 50 | 50 | 50x130-50x130 | 0.000510425 | GEN 1 | 50 mmx130 mm-50 mmx130 mm
1156985 | 300 | 90 | 130 | 50 | 50 | 50x130-50x130 | 0.000510425 | GEN 1 | 50 mmx130 mm-50 mmx130 mm
1157551 | 300 | 90 | 50 | 130 | 130 | 130x50-130x50 | 0.00132725 | GEN 1 | 130 mmx50 mm-130 mmx50 mm
1158838 | 300 | 90 | 130 | 50 | 50 | 50x130-50x130 | 0.000510425 | GEN 1 | 50 mmx130 mm-50 mmx130 mm
1159567 | 300 | 13 | 130 | 50 | 5.69678 | 50x130-50x130 | 0.00007374 | GEN 3 | 50 mmx130 mm-50 mmx130 mm
1159626 | 300 | 90 | 50 | 130 | 130 | 130x50-130x50 | 0.00132725 | GEN 3 | 130 mmx50 mm-130 mmx50 mm
1197353 | 676.794 | 90 | 130 | 50 | 50 | 50x130-50x130 | 0.000510425 | GEN 1 | 50 mmx130 mm-50 mmx130 mm
1197439 | 676.794 | 60 | 50 | 130 | 75.0555 | 130x50-130x50 | 0.000884876 | GEN 1 | 130 mmx50 mm-130 mmx50 mm
1197566 | 676.794 | 60 | 50 | 130 | 75.0555 | 130x50-130x50 | 0.000884876 | GEN 6 | 130 mmx50 mm-130 mmx50 mm
1197574 | 676.794 | 60 | 50 | 130 | 75.0555 | 130x50-130x50 | 0.000884876 | GEN 6 | 130 mmx50 mm-130 mmx50 mm
1197977 | 676.794 | 89.9972 | 130 | 50 | 49.9976 | 50x130-50x130 | 0.000510409 | GEN 3 | 50 mmx130 mm-50 mmx130 mm
