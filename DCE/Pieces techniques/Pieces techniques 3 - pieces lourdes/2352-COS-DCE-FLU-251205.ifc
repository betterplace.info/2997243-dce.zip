Properties of the parts of a building model (IFC2X3), part 4 of 8

# IfcFlowFitting: Coude rectangulaire - Rayon:1 W (13)
Name (Coude rectangulaire - Rayon:1 W:...) | Élévation par rapport au niveau (mm) | Angle (deg) | Hauteur de la gaine (mm) | Largeur de la gaine (mm) = Rayon du centre (mm) | Longueur de la gaine 1 (mm) | Taille | Volume (m3) | Nom du système = Group | Taille globale = Taille libre
1198166 | 676.794 | 90.0028 | 130 | 50 | 50.0024 | 50x130-50x130 | 0.000510441 | GEN 3 | 50 mmx130 mm-50 mmx130 mm
1198261 | 676.794 | 90 | 130 | 50 | 50 | 50x130-50x130 | 0.000510425 | GEN 3 | 50 mmx130 mm-50 mmx130 mm

# IfcFlowFitting: EG-RCAN Té sanitaire de réduction - PVC - Nom. 40 - DWV:Standard (23)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de canalisation; Nom de la famille: EG-RCAN Té sanitaire de réduction - PVC - Nom. 40 - DWV; Nom de la table de consultation: M_Tee Reducing Sanitary - PVC - Sch 40 - DWV
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Numéro OmniClass: 23.60.30.11.14; Sous-projet: Famille : Raccords de canalisation : EG-RCAN Té sanitaire de réduction - PVC - Nom. 40 - DWV; Titre OmniClass: Pipework Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: EG-RCAN Té sanitaire de réduction - PVC - Nom. 40 - DWV; Famille et type: EG-RCAN Té sanitaire de réduction - PVC - Nom. 40 - DWV: Standard; ID du type: 805327; Longueur 9: 0 mm
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 03_PLB
Génie climatique - Classification du système: Sanitaire
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Name (EG-RCAN Té sanitaire de réduction - PVC - Nom. 40 - DWV:Standard:...) | Diamètre nominal max. 12 (mm) = Diamètre nominal 1 (mm) = Diamètre nominal 2 (mm) = Taille maximale (mm) | Libellé de branche centre au bas de prise (mm) = Branche centre au bas de prise (mm) | Longueur 1 (mm) | Longueur 10 (mm) = Rayon extérieur de la prise 1 (mm) = Rayon extérieur de la prise 2 (mm) = Rayon externe max de la prise 13 (mm) | Longueur 11 (mm) = Longueur 13 (mm) = Profondeur de la prise 3 (mm) | Longueur 12 (mm) | Longueur 2 (mm) | Longueur 3 (mm) | Longueur 4 (mm) | Longueur 5 (mm) | Longueur 6 (mm) | Longueur 7 (mm) | Longueur 8 (mm) | Rayon 1 (mm) = Rayon 2 (mm) = Rayon extérieur de la prise 3 (mm) | Rayon du centre (mm) | Rayon extérieur du raccord 1 (mm) = Rayon extérieur du raccord 2 (mm) = Rayon extérieur max du raccord 13 (mm) | Rayon extérieur du raccord 3 (mm) | Niveau | Élévation par rapport au niveau (mm) | Angle (deg) | Diamètre de l'entrée de la prise 1 (mm) = Diamètre de l'entrée de la prise 2 (mm) | Diamètre de l'entrée de la prise 3 (mm) | Diamètre extérieur de la prise 1 (mm) = Diamètre extérieur de la prise 2 (mm) | Diamètre extérieur de la prise 3 (mm) | Diamètre extérieur du raccord 1 (mm) = Diamètre extérieur du raccord 2 (mm) | Diamètre extérieur du raccord 3 (mm) | Diamètre nominal 3 (mm) = Taille minimale (mm) | Epaisseur de la paroi 1 (mm) = Epaisseur de la paroi 2 (mm) | Epaisseur de la paroi 3 (mm) | Longueur bas de prise à bas de prise (mm) | Longueur centre au bas de prise (mm) | Profondeur de la prise 1 (mm) = Profondeur de la prise 2 (mm) | Rayon nominal 1 (mm) = Rayon nominal 2 (mm) | Rayon nominal 3 (mm) | Taille = Taille globale | Taille de la coche 1 (mm) = Taille de la coche 2 (mm) | Taille de la coche 3 (mm) | Volume (m3) | AI_Phase | Type de système | Abréviation du système | Nom du système | Group
945930 | 100 | 80.0277 | 4677.31 | 63.754 | 13.7403 | 4609.57 | 4652.04 | 80.0277 | 4652.05 | 93.768 | 4721.76 | 67.7424 | 80.0228 | 25.2671 | 80.043 | 57.15 | 21.2041 | R-1 | 2408.47 | 89.989 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00203532 | EXISTANT | 3.Eaux Usées | EU | EU 2 | EU 2
946226 | 100 | 80.0277 | 4677.29 | 63.754 | 13.7403 | 4609.57 | 4652.02 | 80.0277 | 4652.02 | 93.768 | 4721.74 | 67.7233 | 80.0288 | 25.2671 | 80.024 | 57.15 | 21.2041 | R-1 | 2413.67 | 90.0026 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.0020351 | EXISTANT | 3.Eaux Usées | EU | EU 2 | EU 2
946569 | 100 | 80.0277 | 4677.29 | 63.754 | 13.7403 | 4609.57 | 4652.03 | 80.0277 | 4652.03 | 93.768 | 4721.74 | 67.7269 | 80.0277 | 25.2671 | 80.0275 | 57.15 | 21.2041 | R-1 | 2391.72 | 90.0001 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00203514 | EXISTANT | 3.Eaux Usées | EU | EU 2 | EU 2
946803 | 100 | 80.0277 | 4677.95 | 63.754 | 13.7403 | 4609.57 | 4652.68 | 80.025 | 4652.8 | 93.7648 | 4722.4 | 68.3811 | 79.8182 | 25.2671 | 80.6853 | 57.15 | 21.2041 | R-1 | 2354.27 | 89.5311 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00204238 | EXISTANT | 3.Eaux Usées | EU | EU 2 | EU 2
947464 | 100 | 80.0277 | 4677.13 | 63.754 | 13.7403 | 4609.57 | 4651.87 | 80.0275 | 4651.84 | 93.7678 | 4721.58 | 67.5649 | 80.0786 | 25.2671 | 79.8658 | 57.15 | 21.2041 | R-1 | 2330.58 | 90.116 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00203335 | EXISTANT | 3.Eaux Usées | EU | EU 2 | EU 2
947579 | 100 | 80.0277 | 4678.49 | 63.754 | 13.7403 | 4609.57 | 4653.23 | 80.0187 | 4653.43 | 93.7574 | 4722.94 | 68.9243 | 79.6397 | 25.2671 | 81.2369 | 57.15 | 21.2041 | R-1 | 2233.92 | 89.1407 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00204839 | EXISTANT | 3.Eaux Usées | EU | EU 2 | EU 2
947937 | 100 | 96.3477 | 4733.56 | 63.754 | 44.45 | 4574.89 | 4669.81 | 96.3366 | 4670.48 | 140.781 | 4778.01 | 158.669 | 95.3691 | 63.754 | 97.8209 | 57.15 | 57.15 | R-1 | 2409.67 | 89.1305 | 114.808 | 114.808 | 127.508 | 127.508 | 114.3 | 114.3 | 100 | 6.35 | 6.35 | 151.282 | 93.4599 | 44.45 | 50 | 50 | 100 mmø-100 mmø-100 mmø | 45.72 | 45.72 | 0.00489206 | EXISTANT | 3.Eaux Vannes | EV | EV 1 | EV 1
947961 | 100 | 96.3477 | 4733.54 | 63.754 | 44.45 | 4574.89 | 4669.79 | 96.3368 | 4670.46 | 140.782 | 4777.99 | 158.652 | 95.3806 | 63.754 | 97.8037 | 57.15 | 57.15 | R-1 | 2394.14 | 89.1406 | 114.808 | 114.808 | 127.508 | 127.508 | 114.3 | 114.3 | 100 | 6.35 | 6.35 | 151.282 | 93.4599 | 44.45 | 50 | 50 | 100 mmø-100 mmø-100 mmø | 45.72 | 45.72 | 0.00489179 | EXISTANT | 3.Eaux Vannes | EV | EV 1 | EV 1
947989 | 100 | 96.3477 | 4731.59 | 63.754 | 44.45 | 4574.89 | 4667.84 | 96.3463 | 4667.6 | 140.796 | 4776.04 | 156.701 | 96.6851 | 63.754 | 95.837 | 57.15 | 57.15 | R-1 | 2379.32 | 90.3045 | 114.808 | 114.808 | 127.508 | 127.508 | 114.3 | 114.3 | 100 | 6.35 | 6.35 | 151.282 | 93.4599 | 44.45 | 50 | 50 | 100 mmø-100 mmø-100 mmø | 45.72 | 45.72 | 0.00486036 | EXISTANT | 3.Eaux Vannes | EV | EV 1 | EV 1
948018 | 100 | 96.3477 | 4733.54 | 63.754 | 44.45 | 4574.89 | 4669.79 | 96.3368 | 4670.46 | 140.782 | 4777.99 | 158.652 | 95.3806 | 63.754 | 97.8037 | 57.15 | 57.15 | R-1 | 2363.88 | 89.1406 | 114.808 | 114.808 | 127.508 | 127.508 | 114.3 | 114.3 | 100 | 6.35 | 6.35 | 151.282 | 93.4599 | 44.45 | 50 | 50 | 100 mmø-100 mmø-100 mmø | 45.72 | 45.72 | 0.00489179 | EXISTANT | 3.Eaux Vannes | EV | EV 1 | EV 1
948936 | 32 | 43.9877 | 4641.91 | 25.2671 | 13.7403 | 4573.46 | 4616.64 | 43.9828 | 4616.85 | 57.7215 | 4655.65 | 68.4445 | 43.6057 | 25.2671 | 44.649 | 21.2041 | 21.2041 | R-1 | 2405.55 | 89.145 | 42.7058 | 42.7058 | 50.5342 | 50.5342 | 42.4081 | 42.4081 | 32 | 3.91422 | 3.91422 | 67.234 | 42.5238 | 13.7403 | 16 | 16 | 32 mmø-32 mmø-32 mmø | 16.9633 | 16.9633 | 0.000277466 | EXISTANT | 3.Eaux Usées | EU | EU 2 | EU 2
1220313 | 100 | 84.1502 | 4690.47 | 63.754 | 19.05 | 4603.75 | 4656.15 | 84.1502 | 4656.15 | 103.2 | 4734.92 | 86.7153 | 84.1503 | 34.3154 | 84.1499 | 57.15 | 30.1625 | RDC | -359.261 | 90.0002 | 114.808 | 60.706 | 127.508 | 68.6308 | 114.3 | 60.325 | 50 | 6.35 | 3.9624 | 80.9752 | 52.4002 | 44.45 | 50 | 25 | 100 mmø-100 mmø-50 mmø | 45.72 | 24.13 | 0.00247312 |  | 3.Unitaire | U | U 2 | EU 8; U 2
1220557 | 100 | 80.0277 | 4677.29 | 63.754 | 13.7403 | 4609.57 | 4652.03 | 80.0277 | 4652.03 | 93.768 | 4721.74 | 67.7252 | 80.0282 | 25.2671 | 80.0258 | 57.15 | 21.2041 | RDC | -370.401 | 90.0013 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00203512 |  | 3.Unitaire | U | U 2 | U 2; EU 6
1221468 | 100 | 80.0277 | 4677.3 | 63.754 | 13.7403 | 4609.57 | 4652.03 | 80.0277 | 4652.03 | 93.768 | 4721.75 | 67.728 | 80.0273 | 25.2671 | 80.0287 | 57.15 | 21.2041 | RDC | -412.326 | 89.9993 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00203516 |  | 3.Unitaire | U | U 2 | EU 7; U 2
1221633 | 100 | 84.1502 | 4690.47 | 63.754 | 19.05 | 4603.75 | 4656.15 | 84.1502 | 4656.15 | 103.2 | 4734.92 | 86.7188 | 84.1489 | 34.3154 | 84.1534 | 57.15 | 30.1625 | RDC | -428.072 | 89.9978 | 114.808 | 60.706 | 127.508 | 68.6308 | 114.3 | 60.325 | 50 | 6.35 | 3.9624 | 80.9752 | 52.4002 | 44.45 | 50 | 25 | 100 mmø-100 mmø-50 mmø | 45.72 | 24.13 | 0.00247316 |  | 3.Unitaire | U | U 2 | EU 9; U 2
1222237 | 100 | 80.0277 | 4677.3 | 63.754 | 13.7403 | 4609.57 | 4652.03 | 80.0277 | 4652.03 | 93.768 | 4721.75 | 67.7277 | 80.0275 | 25.2671 | 80.0283 | 57.15 | 21.2041 | RDC | -338.18 | 89.9995 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00203515 |  | 3.Unitaire | U | U 1 | EU 10; U 1
1222344 | 100 | 96.3477 | 4732.1 | 63.754 | 44.45 | 4574.89 | 4668.35 | 96.3477 | 4668.34 | 140.798 | 4776.55 | 157.212 | 96.3489 | 63.754 | 96.3457 | 57.15 | 57.15 | RDC | -358.322 | 90.0012 | 114.808 | 114.808 | 127.508 | 127.508 | 114.3 | 114.3 | 100 | 6.35 | 6.35 | 151.282 | 93.4599 | 44.45 | 50 | 50 | 100 mmø-100 mmø-100 mmø | 45.72 | 45.72 | 0.00486859 |  | 3.Unitaire | U | U 1 | U 1; EV 2
1222522 | 100 | 80.0277 | 4677.29 | 63.754 | 13.7403 | 4609.57 | 4652.03 | 80.0277 | 4652.03 | 93.768 | 4721.74 | 67.727 | 80.0277 | 25.2671 | 80.0276 | 57.15 | 21.2041 | RDC | -361.528 | 90 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00203514 |  | 3.Unitaire | U | U 1 | EU 5; U 1
1222708 | 100 | 80.0277 | 4678.09 | 63.754 | 13.7403 | 4609.57 | 4652.83 | 80.0237 | 4652.97 | 93.7633 | 4722.54 | 68.526 | 79.771 | 25.2671 | 80.8319 | 57.15 | 21.2041 | RDC | -548.455 | 89.4271 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00204399 |  | 3.Unitaire | U | U 2 | U 2; EU 11
1223498 | 32 | 43.9877 | 4640.7 | 25.2671 | 13.7403 | 4573.46 | 4615.99 | 43.9877 | 4615.99 | 57.728 | 4654.44 | 67.7909 | 43.9877 | 25.2671 | 43.9877 | 21.2041 | 21.2041 | RDC | 395.623 | 90 | 42.7058 | 42.7058 | 50.5342 | 50.5342 | 42.4081 | 42.4081 | 32 | 3.91422 | 3.91422 | 67.234 | 42.5238 | 13.7403 | 16 | 16 | 32 mmø-32 mmø-32 mmø | 16.9633 | 16.9633 | 0.00027523 |  | 3.Eaux Usées | EU | EU 19 | EU 19
1223919 | 100 | 96.3477 | 4732.38 | 63.754 | 44.45 | 4574.89 | 4668.63 | 96.3472 | 4668.76 | 140.797 | 4776.83 | 157.497 | 96.16 | 63.754 | 96.631 | 57.15 | 57.15 | R-1 | 2213.11 | 89.8317 | 114.808 | 114.808 | 127.508 | 127.508 | 114.3 | 114.3 | 100 | 6.35 | 6.35 | 151.282 | 93.4599 | 44.45 | 50 | 50 | 100 mmø-100 mmø-100 mmø | 45.72 | 45.72 | 0.00487318 | EXISTANT | 3.Eaux Usées | EU | EU 2 | EU 2
1224056 | 100 | 96.3477 | 4726.17 | 63.754 | 44.45 | 4574.89 | 4658.29 | 95.8208 | 4653.64 | 140.028 | 4770.62 | 146.804 | 102.479 | 63.754 | 86.7604 | 57.15 | 57.15 | R-1 | 2225.04 | 95.9944 | 114.808 | 114.808 | 127.508 | 127.508 | 114.3 | 114.3 | 100 | 6.35 | 6.35 | 151.282 | 93.4599 | 44.45 | 50 | 50 | 100 mmø-100 mmø-100 mmø | 45.72 | 45.72 | 0.00474638 | EXISTANT | 3.Eaux Usées | EU | EU 2 | EU 2
1226897 | 100 | 80.0277 | 4676.86 | 63.754 | 13.7403 | 4609.57 | 4651.59 | 80.0265 | 4651.51 | 93.7666 | 4721.31 | 67.2873 | 80.1652 | 25.2671 | 79.5895 | 57.15 | 21.2041 | RDC | -419.117 | 90.3146 | 114.808 | 42.7058 | 127.508 | 50.5342 | 114.3 | 42.4081 | 32 | 6.35 | 3.91422 | 64.242 | 42.4599 | 44.45 | 50 | 16 | 100 mmø-100 mmø-32 mmø | 45.72 | 16.9633 | 0.00203028 |  | 3.Unitaire | U | U 2 | U 2; EU 16

# IfcFlowFitting: Extrémité arrondie:Standard (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de gaine; Nom de la famille: Extrémité arrondie
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Sous-projet: Famille : Raccords de gaine : Extrémité arrondie
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Extrémité arrondie; Famille et type: Extrémité arrondie: Standard; ID du type: 576633
Contraintes - Niveau: RDC
Cotes - d: 200 mm; l: 12 mm; r: 100 mm; Taille: 200ø; Volume: 0.000376973 m3
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Type de système: 0.Soufflage; Abréviation du système: S; Classification du système: Soufflage
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 200 mmø
Revêtement - Epaisseur du revêtement: 0 mm; Taille libre: 200 mmø
Name (Extrémité arrondie:Standard:...) | Élévation par rapport au niveau (mm) | Nom du système = Group
976976 | 2850 | S 2
1154040 | 2770 | S 4

# IfcFlowFitting: Manchon - Générique1:Standard (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de canalisation; Nom de la famille: Manchon - Générique1; Nom de la table de consultation: Coupling - Generic
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Sous-projet: Famille : Raccords de canalisation : Manchon - Générique1
Type - Génie climatique - Méthode de perte de charge: Coefficient K à partir du tableau; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Manchon - Générique1; Famille et type: Manchon - Générique1: Standard; ID du type: 804520; Rayon extérieur du raccord: 21.1 mm
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 2918.3 mm
Cotes - Diamètre extérieur du raccord: 42.2 mm; Diamètre nominal: 32 mm; Longueur: 57 mm; Rayon nominal: 16 mm; Taille: 32 mmø-32 mmø; Taille de la coche: 16.88 mm; Taille maximale: 32 mm; Taille minimale: 32 mm; Volume: 0.0000797203 m3
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Type de système: 0.Eau Glacée Aller; Abréviation du système: EGA; Classification du système: Alimentation hydraulique; Nom du système: EGA 1
Génie climatique - Débit - Trajectoire critique: no; Perte de pression: 0 Pa
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø-32 mmø
Group: EGA 1
Name (Manchon - Générique1:Standard:...)
942740
942754

# IfcFlowFitting: Transformation - Générique:Standard (3)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de canalisation; Nom de la famille: Transformation - Générique; Nom de la table de consultation: Transition - Generic
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Sous-projet: Famille : Raccords de canalisation : Transformation - Générique
Type - Génie climatique - Méthode de perte de charge: Coefficient K à partir du tableau; Tableau de coefficient K: Reducer/Coupling/Union/Increaser
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Transformation - Générique; Famille et type: Transformation - Générique: Standard; ID du type: 643819; Visibilité 1: yes; Visibilité 2: no; Visibilité 3: no
Contraintes - Niveau: R-1
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 03_PLB; AI_Phase: EXISTANT
Génie climatique - Type de système: 3.Eaux Usées; Abréviation du système: EU; Classification du système: Sanitaire; Nom du système: EU 2
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Name (Transformation - Générique:Standard:...) | Décalage de la hauteur (mm) | Décalage de la largeur (mm) | Diamètre nominal max. 12 (mm) = Diamètre nominal 1 (mm) = Diamètre nominal 2 (mm) = Taille maximale (mm) = Taille minimale (mm) | Rayon extérieur du raccord 1 (mm) = Rayon extérieur du raccord 2 (mm) | Élévation par rapport au niveau (mm) | Diamètre extérieur du raccord 1 (mm) = Diamètre extérieur du raccord 2 (mm) | Hauteur de décalage | Largeur de décalage | Longueur (mm) | Rayon nominal 1 (mm) = Rayon nominal 2 (mm) | Surface (m2) | Taille = Taille globale | Taille de la coche 1 (mm) = Taille de la coche 2 (mm) | Volume (m3) | Group
947471 | 3037.23 | 3047.75 | 32 | 21.1 | 2396.88 | 42.2 | 5.23082 | 15.7515 | 51 | 16 | 0.00598493 | 32 mmø-32 mmø | 16.88 | 0.0000712307 | EU 2
1223925 | 3063.52 | 3048.23 | 100 | 57.15 | 2240.68 | 114.3 | 65.518 | 50.2283 | 102 | 50 | 0.0372871 | 100 mmø-100 mmø | 45.72 | 0.00104623 | EU 2 | Génie climatique - Débit - Perte de pression: 0 Pa
1224062 | 3032.78 | 3047.28 | 100 | 57.15 | 2265.61 | 114.3 | 34.7763 | 49.2784 | 102 | 50 | 0.0372814 | 100 mmø-100 mmø | 45.72 | 0.00104623 | EU 2; U 1

# IfcFlowFitting: Transformation ronde - Longueur:Standard (12)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de gaine; Nom de la famille: Transformation ronde - Longueur
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Numéro OmniClass: 23.75.70.14; Sous-projet: Famille : Raccords de gaine : Transformation ronde - Longueur; Titre OmniClass: Air Ductwork
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Transformation ronde - Longueur; Famille et type: Transformation ronde - Longueur: Standard; ID du type: 804600
Contraintes - Niveau: RDC
Cotes - Décalage de la largeur: 6096 mm; Longueur fixe de la transformation: 0 mm
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 01_CVC
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Revêtement - Epaisseur du revêtement: 0 mm
Name (Transformation ronde - Longueur:Standard:...) | Élévation par rapport au niveau (mm) | Décalage de la hauteur (mm) | Diamètre de la gaine 1 (mm) | Diamètre de la gaine 2 (mm) | Hauteur de décalage | Largeur de décalage = Rayon de la gaine 1 (mm) | Longueur de la gaine 1 (mm) | Rayon de la gaine 2 (mm) | Surface (m2) | Taille | Volume (m3) | Type de système | Abréviation du système | Classification du système | Nom du système = Group | Taille globale = Taille libre
876923 | 2820 | 6096 | 250 | 200 | 125 | 125 | 50 | 100 | 0.0494529 | 250ø-200ø | 0.00199601 | 0.Soufflage | S | Soufflage | S 1 | 250 mmø-200 mmø
876925 | 2820 | 6096 | 200 | 160 | 100 | 100 | 40 | 80 | 0.0316498 | 200ø-160ø | 0.00102196 | 0.Soufflage | S | Soufflage | S 1 | 200 mmø-160 mmø
887269 | 2800 | 6096 | 250 | 200 | 125 | 125 | 50 | 100 | 0.0494529 | 250ø-200ø | 0.00199601 | 0.Soufflage | S | Soufflage | S 4 | 250 mmø-200 mmø
887339 | 2825 | 6121 | 250 | 200 | 150 | 125 | 50 | 100 | 0.0494529 | 250ø-200ø | 0.00199601 | 0.Soufflage | S | Soufflage | S 2 | 250 mmø-200 mmø
924691 | 2860.82 | 6096 | 160 | 125 | 80 | 80 | 35 | 62.5 | 0.0208699 | 160ø-125ø | 0.000560843 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 2 | 160 mmø-125 mmø
924757 | 2860.82 | 6096 | 200 | 125 | 100 | 100 | 75 | 62.5 | 0.0397198 | 200ø-125ø | 0.00158287 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-125 mmø
926656 | 2860.82 | 6096 | 200 | 160 | 100 | 100 | 40 | 80 | 0.0316498 | 200ø-160ø | 0.00102196 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-160 mmø
942367 | 2809.9 | 6096 | 250 | 200 | 125 | 125 | 50 | 100 | 0.0494529 | 250ø-200ø | 0.00199601 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 250 mmø-200 mmø | Données d'identification - AI_Phase: EXISTANT
1154778 | 2800 | 6096 | 315 | 250 | 157.5 | 157.5 | 65 | 125 | 0.0793236 | 315ø-250ø | 0.0040919 | 0.Soufflage | S | Soufflage | S 4 | 315 mmø-250 mmø
1155436 | 2675 | 6096 | 250 | 315 | 125 | 125 | 65 | 157.5 | 0.0793236 | 315ø-250ø | 0.00409188 | 0.Soufflage | S | Soufflage | S 2 | 315 mmø-250 mmø
1212003 | 2675 | 6096 | 250 | 315 | 125 | 125 | 65 | 157.5 | 0.0793236 | 315ø-250ø | 0.00409188 | 0.Soufflage | S | Soufflage | S 3 | 315 mmø-250 mmø
1228961 | 2820 | 6096 | 125 | 160 | 62.5 | 62.5 | 35 | 80 | 0.0208699 | 160ø-125ø | 0.000560905 | 0.Soufflage | S | Soufflage | S 1 | 160 mmø-125 mmø

# IfcFlowFitting: Té - Générique:Standard (16)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de canalisation; Nom de la famille: Té - Générique; Nom de la table de consultation: Tee - Generic
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Sous-projet: Famille : Raccords de canalisation : Té - Générique
Type - Génie climatique - Méthode de perte de charge: Coefficient K à partir du tableau; Tableau de coefficient K: Tee
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Famille: Té - Générique; Famille et type: Té - Générique: Standard; ID du type: 642936; Type: Standard
Contraintes - Niveau: RDC
Graphismes - Utiliser l'échelle d'annotations: yes
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Name (Té - Générique:Standard:...) | Angle 1 (deg) | Libellé de centre à extrémité (mm) | Rayon extérieur du raccord (mm) | Élévation par rapport au niveau (mm) | Angle (deg) | Centre à extrémité (mm) | Diamètre extérieur du raccord (mm) | Diamètre nominal (mm) = Taille maximale (mm) = Taille minimale (mm) | Rayon nominal (mm) | Taille = Taille globale | Taille de la coche (mm) | Volume (m3) | Sous-projet | Type de système | Abréviation du système | Classification du système | Nom du système = Group
841514 | 89.9932 | 48 | 21.1 | 2918.24 | 89.9932 | 48 | 42.2 | 32 | 16 | 32 mmø-32 mmø-32 mmø | 16.88 | 0.000176351 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | Génie climatique - Débit - Trajectoire critique: no
841530 | 90 | 48 | 21.1 | 2918.3 | 90 | 48 | 42.2 | 32 | 16 | 32 mmø-32 mmø-32 mmø | 16.88 | 0.000176351 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | Génie climatique - Débit - Trajectoire critique: no
842655 | 90 | 48 | 21.1 | 2918.24 | 90 | 48 | 42.2 | 32 | 16 | 32 mmø-32 mmø-32 mmø | 16.88 | 0.000176351 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | Génie climatique - Débit - Trajectoire critique: no
844450 | 90 | 48 | 21.1 | 2918.3 | 90 | 48 | 42.2 | 32 | 16 | 32 mmø-32 mmø-32 mmø | 16.88 | 0.000176351 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | Génie climatique - Débit - Trajectoire critique: no
883839 | 90 | 48 | 21.1 | 2918.3 | 90 | 48 | 42.2 | 32 | 16 | 32 mmø-32 mmø-32 mmø | 16.88 | 0.000176351 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | Génie climatique - Débit - Trajectoire critique: no
884106 | 89.9954 | 48 | 21.1 | 2918.3 | 89.9954 | 48 | 42.2 | 32 | 16 | 32 mmø-32 mmø-32 mmø | 16.88 | 0.000176351 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | Génie climatique - Débit - Trajectoire critique: no
948464 | 90 | 29 | 13.35 | 2717.09 | 90 | 29 | 26.7 | 20 | 10 | 20 mmø-20 mmø-20 mmø | 10.68 | 0.0000423652 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948466 | 89.9977 | 29 | 13.35 | 237.303 | 90.0023 | 29 | 26.7 | 20 | 10 | 20 mmø-20 mmø-20 mmø | 10.68 | 0.0000423652 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
948648 | 90 | 29 | 13.35 | 2602.09 | 90 | 29 | 26.7 | 20 | 10 | 20 mmø-20 mmø-20 mmø | 10.68 | 0.0000423652 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1065975 | 45.0054 | 50.9332 | 21.1 | 2866.5 | 45.0054 | 48 | 42.2 | 32 | 16 | 32 mmø-32 mmø-32 mmø | 16.88 | 0.000178358 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 12 | Données d'identification - AI_Métré canalisation: EAU GLACEE
1067843 | 44.9971 | 50.9435 | 21.1 | 2872.99 | 44.9971 | 48 | 42.2 | 32 | 16 | 32 mmø-32 mmø-32 mmø | 16.88 | 0.000178397 | 01_CVC | 3.Condensats | EU | Sanitaire | EU 17 | Données d'identification - AI_Métré canalisation: EAU GLACEE
1215379 | 90 | 29 | 13.35 | 550.694 | 90 | 29 | 26.7 | 20 | 10 | 20 mmø-20 mmø-20 mmø | 10.68 | 0.0000423652 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1215684 | 90 | 29 | 13.35 | 550.7 | 90 | 29 | 26.7 | 20 | 10 | 20 mmø-20 mmø-20 mmø | 10.68 | 0.0000423652 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1215934 | 90 | 38 | 16.7 | 333.408 | 90 | 38 | 33.4 | 25 | 12.5 | 25 mmø-25 mmø-25 mmø | 13.36 | 0.0000874588 | 03_PLB | 2.Eau Froide Sanitaire | EF | Eau froide sanitaire | EF 1
1229406 | 90 | 48 | 21.1 | 2918.3 | 90 | 48 | 42.2 | 32 | 16 | 32 mmø-32 mmø-32 mmø | 16.88 | 0.000176351 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | Génie climatique - Débit - Trajectoire critique: no
1229432 | 90 | 48 | 21.1 | 2918.3 | 90 | 48 | 42.2 | 32 | 16 | 32 mmø-32 mmø-32 mmø | 16.88 | 0.000176351 | 01_CVC | 0.Eau Glacée Aller | EGA | Alimentation hydraulique | EGA 1 | Génie climatique - Débit - Trajectoire critique: no

# IfcFlowFitting: Té circulaire:Standard (17)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de gaine; Nom de la famille: Té circulaire
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Numéro OmniClass: 23.75.70.14; Sous-projet: Famille : Raccords de gaine : Té circulaire; Titre OmniClass: Air Ductwork
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Té circulaire; Famille et type: Té circulaire: Standard; ID du type: 804602
Contraintes - Niveau: RDC
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 01_CVC
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Revêtement - Epaisseur du revêtement: 0 mm
Name (Té circulaire:Standard:...) | Élévation par rapport au niveau (mm) | Longueur de la gaine 1 (mm) | Longueur de la gaine 3 (mm) | Rayon de la gaine 1 (mm) | Rayon de la gaine 3 (mm) | Taille | Volume (m3) | Type de système | Abréviation du système | Classification du système | Nom du système = Group | Taille globale = Taille libre
874941 | 2820 | 225 | 175 | 125 | 62.5 | 250ø-250ø-125ø | 0.0117073 | 0.Soufflage | S | Soufflage | S 1 | 250 mmø-250 mmø-125 mmø
875180 | 2820 | 225 | 150 | 100 | 62.5 | 200ø-200ø-125ø | 0.00774509 | 0.Soufflage | S | Soufflage | S 1 | 200 mmø-200 mmø-125 mmø
875198 | 2820 | 225 | 130 | 80 | 62.5 | 160ø-160ø-125ø | 0.00521937 | 0.Soufflage | S | Soufflage | S 1 | 160 mmø-160 mmø-125 mmø
875220 | 2820 | 225 | 112.5 | 62.5 | 62.5 | 125ø-125ø-125ø | 0.00349063 | 0.Soufflage | S | Soufflage | S 1 | 125 mmø-125 mmø-125 mmø
923605 | 2860.82 | 225 | 130 | 80 | 62.5 | 160ø-160ø-125ø | 0.00521937 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 2 | 160 mmø-160 mmø-125 mmø
923685 | 2860.82 | 225 | 130 | 80 | 62.5 | 160ø-160ø-125ø | 0.00521937 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 2 | 160 mmø-160 mmø-125 mmø
923832 | 2860.82 | 225 | 150 | 100 | 62.5 | 200ø-200ø-125ø | 0.00774509 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-200 mmø-125 mmø
923936 | 2860.82 | 225 | 112.5 | 62.5 | 62.5 | 125ø-125ø-125ø | 0.00349063 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 2 | 125 mmø-125 mmø-125 mmø
924501 | 2860.82 | 300 | 150 | 100 | 100 | 200ø-200ø-200ø | 0.01147 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-200 mmø-200 mmø
941066 | 2809.9 | 225 | 175 | 125 | 62.5 | 250ø-250ø-125ø | 0.0117073 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 250 mmø-250 mmø-125 mmø | Données d'identification - AI_Phase: EXISTANT
941083 | 2809.9 | 225 | 175 | 125 | 62.5 | 250ø-250ø-125ø | 0.0117073 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 250 mmø-250 mmø-125 mmø | Données d'identification - AI_Phase: EXISTANT
941225 | 2809.9 | 225 | 175 | 125 | 62.5 | 250ø-250ø-125ø | 0.0117073 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 250 mmø-250 mmø-125 mmø | Données d'identification - AI_Phase: EXISTANT
941232 | 2809.9 | 225 | 175 | 125 | 62.5 | 250ø-250ø-125ø | 0.0117073 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 250 mmø-250 mmø-125 mmø | Données d'identification - AI_Phase: EXISTANT
941454 | 2809.9 | 225 | 175 | 125 | 62.5 | 250ø-250ø-125ø | 0.0117073 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 250 mmø-250 mmø-125 mmø | Données d'identification - AI_Phase: EXISTANT
941614 | 2809.9 | 225 | 175 | 125 | 62.5 | 250ø-250ø-125ø | 0.0117073 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 250 mmø-250 mmø-125 mmø | Données d'identification - AI_Phase: EXISTANT
1216749 | 2860.82 | 225 | 130 | 80 | 62.5 | 160ø-160ø-125ø | 0.00521937 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 2 | 160 mmø-160 mmø-125 mmø
1217152 | 2860.82 | 225 | 130 | 80 | 62.5 | 160ø-160ø-125ø | 0.00521937 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 2 | 160 mmø-160 mmø-125 mmø

# IfcFlowFitting: Té de réduction rectangulaire - DTL:Standard, Té de réduction rectangulaire - DTL:Standard:1158782
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de gaine; Nom de la famille: Té de réduction rectangulaire - DTL
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Numéro OmniClass: 23.75.70.14; Sous-projet: Famille : Raccords de gaine : Té de réduction rectangulaire - DTL; Titre OmniClass: Air Ductwork
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Décalage: 65 mm; Famille: Té de réduction rectangulaire - DTL; Famille et type: Té de réduction rectangulaire - DTL: Standard; ID du type: 804618; Longueur 3: 215 mm; Longueur 4: 215 mm; Longueur 5: 280 mm; Longueur 6: 215 mm; Longueur 7: 280 mm; Longueur 8: 3048 mm
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 300 mm
Cotes - Droite rectiligne extérieure: 150 mm; Droite rectiligne intérieure: 150 mm; Gauche rectiligne extérieure: 150 mm; Gauche rectiligne intérieure: 150 mm; Largeur extérieure à droite: 130 mm; Largeur extérieure à gauche: 130 mm; Largeur intérieure: 130 mm; Mi-largeur extérieure à droite: 65 mm; Mi-largeur extérieure à gauche: 65 mm; Profondeur intérieure: 50 mm; Taille: 130x50-130x50-130x50; Volume: 0.00377 m3
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 02_ELE
Génie climatique - Type de système: 0.Goulotte; Abréviation du système: GEN; Classification du système: Soufflage; Nom du système: GEN 1
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 130 mmx50 mm-130 mmx50 mm-130 mmx50 mm
Revêtement - Epaisseur du revêtement: 0 mm; Taille libre: 130 mmx50 mm-130 mmx50 mm-130 mmx50 mm
Group: GEN 1

# IfcFlowFitting: Té rectangulaire:Standard (4)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de gaine; Nom de la famille: Té rectangulaire
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Numéro OmniClass: 23.75.70.14; Sous-projet: Famille : Raccords de gaine : Té rectangulaire; Titre OmniClass: Air Ductwork
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Té rectangulaire; Famille et type: Té rectangulaire: Standard; ID du type: 804620
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 300 mm
Cotes - Accotement: 25 mm; Hauteur de la gaine: 50 mm; Largeur de la gaine 1: 130 mm; Largeur de la gaine 3: 130 mm; Longueur1a: 65 mm; Longueur3a: 65 mm; Longueur de la gaine 1: 90 mm; Longueur de la gaine 3: 90 mm; Taille: 130x50-130x50-130x50; Volume: 0.0013325 m3
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 02_ELE
Génie climatique - Type de système: 0.Goulotte; Abréviation du système: GEN; Classification du système: Soufflage
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 130 mmx50 mm-130 mmx50 mm-130 mmx50 mm
Revêtement - Epaisseur du revêtement: 0 mm; Taille libre: 130 mmx50 mm-130 mmx50 mm-130 mmx50 mm
Name (Té rectangulaire:Standard:...) | Nom du système = Group
1197351 | GEN 1
1197972 | GEN 3
1198144 | GEN 3
1198238 | GEN 3

# IfcFlowFitting: Té sanitaire double - PVC - Nom. 40 - DWV:Standard (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de canalisation; Nom de la famille: Té sanitaire double - PVC - Nom. 40 - DWV; Nom de la table de consultation: M_Tee Double Sanitary - PVC - Sch 40 - DWV
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Numéro OmniClass: 23.60.30.11.14; Sous-projet: Famille : Raccords de canalisation : Té sanitaire double - PVC - Nom. 40 - DWV; Titre OmniClass: Pipework Fittings
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Té sanitaire double - PVC - Nom. 40 - DWV; Famille et type: Té sanitaire double - PVC - Nom. 40 - DWV: Standard; ID du type: 804533; Libellé de branche centre au bas de prise: 98.425 mm; Longueur 11: 142.875 mm; Longueur 13: 142.875 mm; Longueur 16: 4670.43 mm; Longueur 18: 44.45 mm; Longueur 19: 44.45 mm; Longueur 2: 0 mm; Longueur 3: 57.15 mm; Longueur 4: 98.425 mm; Longueur 5: 98.425 mm; Longueur 8: 44.45 mm; Longueur 9: 44.45 mm; Longueur centre au bas de prise: 98.425 mm; Rayon 1: 63.754 mm; Rayon 2: 63.754 mm; Rayon 3: 63.754 mm; Rayon 4: 63.754 mm; Rayon extérieur de la prise: 63.754 mm; Rayon extérieur du raccord: 57.15 mm
Contraintes - Niveau: RDC
Cotes - Branche centre au bas de prise: 98.425 mm; Diamètre de l'entrée de la prise: 114.808 mm; Diamètre extérieur de la prise: 127.508 mm; Diamètre extérieur du raccord: 114.3 mm; Diamètre nominal: 100 mm; Epaisseur de la paroi: 6.35 mm; Longueur bas de prise à bas de prise: 155.575 mm; Profondeur de la prise: 44.45 mm; Rayon nominal: 50 mm; Taille: 100 mmø-100 mmø-100 mmø-100 mmø; Taille de la coche: 45.72 mm; Taille maximale: 100 mm; Taille minimale: 100 mm
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 03_PLB
Génie climatique - Classification du système: Sanitaire
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 100 mmø-100 mmø-100 mmø-100 mmø
Name (Té sanitaire double - PVC - Nom. 40 - DWV:Standard:...) | Angle min 12 (deg) = Angle 1 (deg) | Longueur 1 (mm) | Longueur 10 (mm) | Longueur 12 (mm) | Longueur 14 (mm) | Longueur 15 (mm) | Longueur 17 (mm) | Longueur 6 (mm) | Longueur 7 (mm) | Rayon du centre 1 (mm) | Rayon du centre 2 (mm) | Élévation par rapport au niveau (mm) | Angle 2 (deg) | Volume (m3) | Type de système | Abréviation du système | Nom du système | Group
1212784 | 90 | 57.15 | 98.425 | 98.425 | 162.179 | 57.15 | 4670.43 | 98.425 | 98.425 | 98.425 | 98.425 | 220.513 | 90 | 0.00703903 | 3.Eaux Vannes | EV | EV 4 | EV 4
1220935 | 89.9993 | 57.1512 | 98.4268 | 98.422 | 162.18 | 63.7553 | 4670.42 | 98.4242 | 98.4264 | 98.4263 | 98.4229 | -391.401 | 90.0012 | 0.0071068 | 3.Unitaire | U | U 2 | EV 4; U 2

# IfcFlowFitting: Union circulaire:Standard (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de gaine; Nom de la famille: Union circulaire
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Sous-projet: Famille : Raccords de gaine : Union circulaire
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Famille: Union circulaire; Famille et type: Union circulaire: Standard; ID du type: 579855
Contraintes - Niveau: RDC
Cotes - l: 75 mm
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 01_CVC
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Revêtement - Epaisseur du revêtement: 0 mm
Name (Union circulaire:Standard:...) | Élévation par rapport au niveau (mm) | d (mm) | r (mm) | Taille | Volume (m3) | Type de système | Abréviation du système | Classification du système | Nom du système = Group | Taille globale = Taille libre
942522 | 2860.82 | 200 | 100 | 200ø-200ø | 0.00235608 | 0.Extraction (VMC) | VMC | Extraction d'air | VMC 8 | 200 mmø-200 mmø
942662 | 2809.92 | 250 | 125 | 250ø-250ø | 0.00368137 | 0.Soufflage | S | Soufflage | S 7 | 250 mmø-250 mmø

# IfcFlowSegment: Canalisation:Acier - Té (134)
In: RDC
Type - Autre - Catégorie: Canalisation; Nom de la famille: Canalisation
Type - Données d'identification - Nom du type: Acier - Té; Sous-projet: Canalisation
Pset_DistributionFlowElementCommon - Reference: Acier - Té; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Autre - Famille: Canalisation; Famille et type: Canalisation: Acier - Té; ID du type: 805935; Type: Acier - Té
Contraintes - Justification horizontale: Centre; Justification verticale: Milieu
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Matériau: Acier, carbone; Nomenclature/type: Nomenclature 40; Rugosité: 0.04572 mm; Segment de canalisation: Acier au carbone - Série 40; Type de connexion: Générique
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Name (Canalisation:Acier - Té:...) | Length (mm) = Longueur (mm) | Arase inférieure à son extrémité amont (mm) = Arase inférieure avec isolant à son extrémité amont (mm) | Arase inférieure à son extrémité aval (mm) = Arase inférieure avec isolant à son extrémité aval (mm) | Arase supérieure à son extrémité amont (mm) = Arase supérieure avec isolant à son extrémité amont (mm) | Arase supérieure à son extrémité aval (mm) = Arase supérieure avec isolant à son extrémité aval (mm) | Élévation centrale de départ (mm) = Elévation du milieu (mm) | Élévation centrale de fin (mm) | Elévation de l'axe à son extrémité amont (mm) | Elévation de l'axe à son extrémité aval (mm) | Elévation du fond (fil d'eau) à son extrémité amont (mm) | Elévation du fond (fil d'eau) à son extrémité aval (mm) | Elévation du point haut intérieur du tube à son extrémité amont (mm) | Elévation du point haut intérieur du tube à son extrémité aval (mm) | Niveau de référence | Diamètre extérieur (mm) | Diamètre intérieur (mm) | Epaisseur de paroi (mm) | Taille = Taille globale | Abréviation du système | Classification du système | Diamètre (mm) | Elévation du fond (fil d'eau) (mm) | Nom du système = Group | Surface (m2) | Type de système | Débit (m3/s) = Débit supplémentaire (m3/s) = Facteur de frottement = Frottement = Nombre de Reynolds = Perte de pression (Pa) = Pression dynamique (Pa) = Vitesse (m/s) | Etat du flux | Limite de boucle = Trajectoire critique | Rugosité relative | Tronçon
840887 | 2919.47 | 2897.16 | 2897.16 | 2939.32 | 2939.32 | 2918.24 | 2918.24 | 2918.24 | 2918.24 | 2900.71 | 2900.71 | 2935.77 | 2935.77 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.71 | EGA 1 | 0.293498 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 1
840943 | 2235.09 | 2708.92 | 2708.92 | 2751.08 | 2751.08 | 2730 | 2730 | 2730 | 2730 | 2712.47 | 2712.47 | 2747.53 | 2747.53 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2712.47 | EGA 1 | 0.224696 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 1
841073 | 3490.35 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.350889 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5 | Données d'identification - AI_Phase: EXISTANT
841079 | 2914.9 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.293038 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 1
841083 | 2235.09 | 2708.92 | 2708.92 | 2751.08 | 2751.08 | 2730 | 2730 | 2730 | 2730 | 2712.47 | 2712.47 | 2747.53 | 2747.53 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2712.47 | EGA 1 | 0.224696 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 1
841512 | 785.31 | 2897.16 | 2897.16 | 2939.32 | 2939.32 | 2918.24 | 2918.24 | 2918.24 | 2918.24 | 2900.71 | 2900.71 | 2935.77 | 2935.77 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.71 | EGA 1 | 0.078948 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 9
841516 | 695.575 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.0699268 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 9
841518 | 23.1148 | 2880.76 | 2864.42 | 2910.58 | 2894.23 | 2895.67 | 2879.33 | 2895.67 | 2879.33 | 2883.28 | 2866.93 | 2908.06 | 2891.72 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2866.93 | EGA 1 | 0.00232376 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 9 | Contraintes - Inclinaison: 1
841522 | 29.3285 | 2835.62 | 2835.62 | 2877.78 | 2877.78 | 2856.7 | 2856.7 | 2856.7 | 2856.7 | 2839.17 | 2839.17 | 2874.23 | 2874.23 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2839.17 | EGA 1 | 0.00294842 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 9
841526 | 7.11485 | 2869.45 | 2864.42 | 2899.27 | 2894.23 | 2879.33 | 2884.36 | 2884.36 | 2879.33 | 2871.97 | 2866.93 | 2896.75 | 2891.72 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2866.93 | EGA 1 | 0.000715263 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 9 | Contraintes - Inclinaison: 1
841731 | 12564 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 1.26308 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 7
841733 | 12671.6 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 1.27389 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 7
842643 | 23.1148 | 2880.76 | 2864.42 | 2910.58 | 2894.23 | 2895.67 | 2879.33 | 2895.67 | 2879.33 | 2883.28 | 2866.93 | 2908.06 | 2891.72 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2866.93 | EGA 1 | 0.00232376 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5 | Contraintes - Inclinaison: 1
842647 | 30.9372 | 2835.62 | 2835.62 | 2877.78 | 2877.78 | 2856.7 | 2856.7 | 2856.7 | 2856.7 | 2839.17 | 2839.17 | 2874.23 | 2874.23 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2839.17 | EGA 1 | 0.00311015 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
842651 | 7.02972 | 2869.39 | 2864.42 | 2899.21 | 2894.23 | 2879.33 | 2884.3 | 2884.3 | 2879.33 | 2871.91 | 2866.93 | 2896.69 | 2891.72 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2866.93 | EGA 1 | 0.000706705 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5 | Contraintes - Inclinaison: 1
842712 | 2988 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.300387 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
843745 | 1523.63 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.153172 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
843793 | 1611.82 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.162038 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
843806 | 1309.06 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.131602 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
843829 | 1399.13 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.140656 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
843888 | 55.3452 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.0055639 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
843901 | 151.798 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.0152604 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
844073 | 469.552 | 2708.92 | 2708.92 | 2751.08 | 2751.08 | 2730 | 2730 | 2730 | 2730 | 2712.47 | 2712.47 | 2747.53 | 2747.53 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2712.47 | EGA 1 | 0.0472046 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
844104 | 469.552 | 2708.92 | 2708.92 | 2751.08 | 2751.08 | 2730 | 2730 | 2730 | 2730 | 2712.47 | 2712.47 | 2747.53 | 2747.53 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2712.47 | EGA 1 | 0.0472046 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
844158 | 124.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2762 | 2886.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2886.3 | 2762 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2762 | EGA 1 | 0.0124959 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
844191 | 124.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2762 | 2886.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2886.3 | 2762 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2762 | EGA 1 | 0.0124959 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
844226 | 124.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2762 | 2886.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2886.3 | 2762 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2762 | EGA 1 | 0.0124959 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
844255 | 124.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2762 | 2886.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2886.3 | 2762 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2762 | EGA 1 | 0.0124959 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
844451 | 6318.63 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.635218 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 3
844762 | 1451.96 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.145967 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 1
844787 | 1562.28 | 2897.16 | 2897.16 | 2939.32 | 2939.32 | 2918.24 | 2918.24 | 2918.24 | 2918.24 | 2900.71 | 2900.71 | 2935.77 | 2935.77 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.71 | EGA 1 | 0.157057 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 1
883674 | 2941.5 | 2897.16 | 2897.16 | 2939.32 | 2939.32 | 2918.24 | 2918.24 | 2918.24 | 2918.24 | 2900.71 | 2900.71 | 2935.77 | 2935.77 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.71 | EGA 1 | 0.295712 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 4
883699 | 2826.7 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.284171 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 4
883821 | 3679 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.369854 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
883825 | 3589.13 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.360819 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
883827 | 23.0711 | 2880.76 | 2864.45 | 2910.58 | 2894.27 | 2895.67 | 2879.36 | 2895.67 | 2879.36 | 2883.28 | 2866.97 | 2908.06 | 2891.75 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2866.97 | EGA 1 | 0.00231936 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6 | Contraintes - Inclinaison: 1
883831 | 29.3904 | 2835.65 | 2835.65 | 2877.81 | 2877.81 | 2856.73 | 2856.73 | 2856.73 | 2856.73 | 2839.2 | 2839.2 | 2874.26 | 2874.26 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2839.2 | EGA 1 | 0.00295464 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
883835 | 7.07107 | 2869.45 | 2864.45 | 2899.27 | 2894.27 | 2879.36 | 2884.36 | 2884.36 | 2879.36 | 2871.97 | 2866.97 | 2896.75 | 2891.75 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2866.97 | EGA 1 | 0.000710861 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6 | Contraintes - Inclinaison: 1
883858 | 10289.6 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 1.03442 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 2
883994 | 10289.6 | 2897.16 | 2897.16 | 2939.32 | 2939.32 | 2918.24 | 2918.24 | 2918.24 | 2918.24 | 2900.71 | 2900.71 | 2935.77 | 2935.77 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.71 | EGA 1 | 1.03442 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 2
884039 | 115.309 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.0115921 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
884047 | 439.552 | 2708.92 | 2708.92 | 2751.08 | 2751.08 | 2730 | 2730 | 2730 | 2730 | 2712.47 | 2712.47 | 2747.53 | 2747.53 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2712.47 | EGA 1 | 0.0441886 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
884049 | 439.552 | 2708.92 | 2708.92 | 2751.08 | 2751.08 | 2730 | 2730 | 2730 | 2730 | 2712.47 | 2712.47 | 2747.53 | 2747.53 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2712.47 | EGA 1 | 0.0441886 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
884051 | 124.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2762 | 2886.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2886.3 | 2762 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2762 | EGA 1 | 0.0124959 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
884057 | 124.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2762 | 2886.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2886.3 | 2762 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2762 | EGA 1 | 0.0124959 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
884063 | 124.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2762 | 2886.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2886.3 | 2762 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2762 | EGA 1 | 0.0124959 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
884067 | 124.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2762 | 2886.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2886.3 | 2762 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2762 | EGA 1 | 0.0124959 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
884107 | 6311.39 | 2897.16 | 2897.16 | 2939.32 | 2939.32 | 2918.24 | 2918.24 | 2918.24 | 2918.24 | 2900.71 | 2900.71 | 2935.77 | 2935.77 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.71 | EGA 1 | 0.63449 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 3
889828 | 2963.79 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -271.699 | FR 3 | 0.232775 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
889868 | 2963.79 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -271.699 | FR 4 | 0.232775 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
889909 | 2963.79 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -271.699 | FR 4 | 0.232775 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
889915 | 2963.79 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | 2692.09 | -271.699 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -271.699 | FR 3 | 0.232775 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
926519 | 28.1776 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 4 | 0.00221307 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
940368 | 6000.2 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.603206 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5 | Données d'identification - AI_Phase: EXISTANT
940370 | 5889.86 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.592113 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5 | Données d'identification - AI_Phase: EXISTANT
940420 | 488 | 3438.3 | 2950.3 | 3438.3 | 2950.3 | 2950.3 | 3438.3 | 3438.3 | 2950.3 | 3438.3 | 2950.3 | 3438.3 | 2950.3 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2950.3 | EGA 1 | 0.0490591 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5 | Données d'identification - AI_Phase: EXISTANT
940451 | 488 | 3438.3 | 2950.3 | 3438.3 | 2950.3 | 2950.3 | 3438.3 | 3438.3 | 2950.3 | 3438.3 | 2950.3 | 3438.3 | 2950.3 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2950.3 | EGA 1 | 0.0490591 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5 | Données d'identification - AI_Phase: EXISTANT
942738 | 56.9596 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.0057262 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
942752 | 3384.15 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.340212 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5 | Données d'identification - AI_Phase: EXISTANT
956239 | 113.032 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.0113632 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
969647 | 52.6855 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.00529652 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
969663 | 422.503 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.0424747 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
1065497 | 148.654 | 2848.41 | 2846.18 | 2890.57 | 2888.34 | 2867.26 | 2869.49 | 2869.49 | 2867.26 | 2851.96 | 2849.73 | 2887.01 | 2884.78 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2849.73 | EU 12 | 0.0149444 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1065501 | 1933.29 | 2878.36 | 2849.37 | 2920.52 | 2891.53 | 2899.44 | 2870.45 | 2899.44 | 2870.45 | 2881.92 | 2852.92 | 2916.97 | 2887.97 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2852.92 | EU 12 | 0.194355 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
