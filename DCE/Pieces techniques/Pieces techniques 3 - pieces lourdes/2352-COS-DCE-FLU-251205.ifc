Properties of the parts of a building model (IFC2X3), part 8 of 8

# IfcFlowTerminal: AI_Eqpmt elec_Borne véhicule électrique:Borne simple, AI_Eqpmt elec_Borne véhicule électrique:Borne simple:1174640
Type - Visibilité - AI_Borne Double: no; AI_Borne simple: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Type - Pset_ProductRequirements - Category: EL_POWERCONSUMER
Pset_DistributionFlowElementCommon - Reference: Borne simple; sets with these values: 2
Autre - ButtonsDist: 67.5 mm; Depth_Safe: 200 mm; Famille: AI_Eqpmt elec_Borne véhicule électrique; Famille et type: AI_Eqpmt elec_Borne véhicule électrique: Borne simple; Height_Safe: 1425 mm; ID du type: 1174626; Type: Borne simple; Width_Safe: 330 mm
Contraintes - Décalage par rapport à l'hôte: 0 mm; Élévation par rapport au niveau: 0 mm; Niveau: R-1; Hôte: Niveau : R-1
Cotes - Depth: 200 mm; Height: 1425 mm; Surface: 1.72262 m2; Volume: 0.0714377 m3; Width: 330 mm
Electricité - Circuit - Données électriques: 230 V/1-3 VA
Données d'identification - Sous-projet: 02_ELE; Function Code: E6113; Identifiant: 5
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowTerminal: AI_Eqpmt elec_Tableau Electrique:Baie de brassage 600x600, AI_Eqpmt elec_Tableau Electrique:Baie de brassage 600x600:862958
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Tableaux/Baies; Nom de la famille: AI_Eqpmt elec_Tableau Electrique
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 1500 mm; AI_Largeur Equipement: 600 mm; AI_Longueur Equipement: 600 mm
Type - Données d'identification - Nom du type: Baie de brassage 600x600; Numéro OmniClass: 23.80.30.11.17; Sous-projet: Famille : Tableaux/Baies : AI_Eqpmt elec_Tableau Electrique; Titre OmniClass: Distribution Boards and Control Panels
Pset_DistributionFlowElementCommon - Reference: Baie de brassage 600x600; sets with these values: 2
Autre - Famille: AI_Eqpmt elec_Tableau Electrique; Famille et type: AI_Eqpmt elec_Tableau Electrique: Baie de brassage 600x600; ID du type: 862943; Type: Baie de brassage 600x600
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 0 mm; Élévation par rapport au niveau: 0 mm; Hôte: Niveau : RDC
Cotes - Surface: 2.16 m2; Volume: 0.54 m3
Electricité - Circuit - Boîtes de raccordement: yes; Cosses d'artère secondaire: yes; Données électriques: 220 V/1-0 VA; Intensité nominale MCB: 1 A; Option de numérotation de circuit: Par défaut
Electricité - Charges - Coefficient d'utilisation global: 1; Puissance apparente des boîtes de raccordement Phase A: 0 W; Puissance apparente des boîtes de raccordement Phase B: 0 W; Puissance apparente des boîtes de raccordement Phase C: 0 W; Puissance apparente du circuit de dérivation Phase A: 0 W; Puissance apparente du circuit de dérivation Phase B: 0 W; Puissance apparente du circuit de dérivation Phase C: 0 W; Puissance apparente - Phase A: 0 W; Puissance apparente - Phase B: 0 W; Puissance apparente - Phase C: 0 W; Puissance installée totale: 0 W; Puissance utilisée totale estimée: 0 W
Données d'identification - Sous-projet: 02_ELE; Identifiant: 3
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowTerminal: AI_Eqpmt genie clim_Canalfast 315:AI_Eqpmt genie clim_Canalfast 315 (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Equipement de génie climatique; Nom de la famille: AI_Eqpmt genie clim_Canalfast 315
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Diamètre Equipement: 434 mm; AI_Longueur Equipement: 780 mm; AI_Rayon Equipement: 217 mm
Type - Données d'identification - Nom du type: AI_Eqpmt genie clim_Canalfast 315; Numéro OmniClass: 23.75.00.00; Sous-projet: Famille : Equipement de génie climatique : AI_Eqpmt genie clim_Canalfast 315; Titre OmniClass: Climate Control (HVAC)
Type - Génie climatique - Classification: Aucun
Pset_DistributionFlowElementCommon - Reference: AI_Eqpmt genie clim_Canalfast 315; sets with these values: 2
Autre - Famille: AI_Eqpmt genie clim_Canalfast 315; Famille et type: AI_Eqpmt genie clim_Canalfast 315: AI_Eqpmt genie clim_Canalfast 315; ID du type: 880438; Type: AI_Eqpmt genie clim_Canalfast 315
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2675 mm; Élévation par rapport au niveau: 2675 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.548388 m2; Volume: 0.0829269 m3
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Classification du système: Extraction d'air
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Eqpmt genie clim_Canalfast 315:AI_Eqpmt genie clim_Canalfast 315:...) | Identifiant | Nom du système | Group
880470 | 24 | S 2,S 3 | S 2; S 3
880913 | 25 | S 4,S 5 | S 4; S 5

# IfcFlowTerminal: AI_Eqpmt genie clim_Cassette plafonnière:Cassette 600x600 (9)
In: RDC
Type - Material: <Unnamed>, Default
Type - Autre - Catégorie: Equipement de génie climatique; Nom de la famille: AI_Eqpmt genie clim_Cassette plafonnière
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Body Width: 500 mm; Decor Panel Height: 10 mm; Decor Panel Width: 600 mm; Grille 1 Length And Width: 240 mm; Grille 1 Void Length And Width: 250 mm; Grille 2 Length: 323.333 mm; Grille 2 Void Length: 333.333 mm; Grille 2 Void Width: 55.5556 mm; Grille 2 Width: 45.5556 mm; Radius 1: 52.5 mm; Radius 2: 62.5 mm
Type - Données d'identification - Nom du type: Cassette 600x600; Sous-projet: Famille : Equipement de génie climatique : AI_Eqpmt genie clim_Cassette plafonnière
Type - Génie climatique - Classification: Aucun
Type - Génie climatique - Débit - Pressure Loss: 0 Pa
Pset_DistributionFlowElementCommon - Reference: Cassette 600x600; sets with these values: 2
Autre - Famille: AI_Eqpmt genie clim_Cassette plafonnière; Famille et type: AI_Eqpmt genie clim_Cassette plafonnière: Cassette 600x600; ID du type: 838051; Type: Cassette 600x600
Contraintes - Hôte: Niveau : RDC; Niveau: RDC
Cotes - Body Height: 285 mm; Fresh Air Supply Radius: 100 mm; Surface: 1.18177 m2; Volume: 0.0092427 m3
Graphismes - Arrow Hatch Yes/No: yes; Arrow Yes/No: yes
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Classification du système: Soufflage
Génie climatique - Débit - Flow: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Eqpmt genie clim_Cassette plafonnière:Cassette 600x600:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Commentaires | Identifiant
839640 | 2680 | 4 kWf | 1
839830 | 2680 | 4 kWf | 2
839838 | 2680 | 4 kWf | 3
839965 | 2680 | 3,6 kWf | 4
839966 | 2680 | 4,5 kWf | 5
839967 | 2660 | 5,1 kWf | 6
839987 | 2680 | 4,6 kWf | 7
840017 | 2680 |  | 8
840336 | 2680 | 3,3 kWf | 9

# IfcFlowTerminal: AI_Eqpmt genie clim_Commande centralisée Clim:Commande centralisée Clim, AI_Eqpmt genie clim_Commande centralisée Clim:Commande centralisée Clim:1062824
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Equipement de génie climatique; Nom de la famille: AI_Eqpmt genie clim_Commande centralisée Clim
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 120 mm; AI_Largeur Equipement: 30 mm; AI_Longueur Equipement: 180 mm
Type - Données d'identification - Nom du type: Commande centralisée Clim; Numéro OmniClass: 23.80.00.00; Sous-projet: Famille : Equipement de génie climatique : AI_Eqpmt genie clim_Commande centralisée Clim; Titre OmniClass: Electric Power and Lighting
Type - Génie climatique - Classification: Aucun
Pset_DistributionFlowElementCommon - Reference: Commande centralisée Clim; sets with these values: 2
Autre - Famille: AI_Eqpmt genie clim_Commande centralisée Clim; Famille et type: AI_Eqpmt genie clim_Commande centralisée Clim: Commande centralisée Clim; ID du type: 1054475; Type: Commande centralisée Clim
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 900 mm; Élévation par rapport au niveau: 900 mm; Hôte: Niveau : RDC
Cotes - AI_Décalage symbole vertical: 0 mm; Surface: 0.0306 m2; Volume: 0.000648 m3
Données d'identification - Sous-projet: 01_CVC; Identifiant: 55
Génie climatique - Classification du système: Puissance
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowTerminal: AI_Eqpmt genie clim_Commande murale Clim:Commande murale Clim (15)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Equipement de génie climatique; Nom de la famille: AI_Eqpmt genie clim_Commande murale Clim
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 120 mm; AI_Largeur Equipement: 30 mm; AI_Longueur Equipement: 70 mm
Type - Données d'identification - Nom du type: Commande murale Clim; Sous-projet: Famille : Equipement de génie climatique : AI_Eqpmt genie clim_Commande murale Clim
Type - Génie climatique - Classification: Aucun
Pset_DistributionFlowElementCommon - Reference: Commande murale Clim; sets with these values: 2
Autre - Famille: AI_Eqpmt genie clim_Commande murale Clim; Famille et type: AI_Eqpmt genie clim_Commande murale Clim: Commande murale Clim; ID du type: 922591; Type: Commande murale Clim
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - AI_Décalage symbole horizontal: 0 mm; Surface: 0.0185328 m2; Volume: 0.000267683 m3
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Classification du système: Communication
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Eqpmt genie clim_Commande murale Clim:Commande murale Clim:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | AI_Décalage symbole vertical (mm) | Identifiant
922654 | 1130 | 0 | 32
922775 | 1130 | 0 | 33
922943 | 1130 | 0 | 34
922996 | 1130 | 0 | 35
923029 | 1130 | 0 | 36
923065 | 1130 | 0 | 37
923107 | 1130 | 0 | 38
923151 | 1130 | 0 | 39
923237 | 1130 | 0 | 40
923245 | 1130 | 0 | 41
940343 | 960 | 380 | 51
1241667 | 1130 | 0 | 56
1241693 | 1130 | 0 | 57
1241747 | 1130 | 0 | 59
1242392 | 1130 | 0 | 62 | Données d'identification - Modifié par: christophe.sautron

# IfcFlowTerminal: AI_Eqpmt genie clim_Préparateur instantané compact:AI_Eqpmt genie clim_Préparateur instantané compact (3)
In: RDC
Type - Material: Stiebel Eltron - Plastic - White, Stiebel Eltron - Metal - Chrome, Stiebel Eltron - Logo - DCE, Stiebel Eltron - Plastic - Transparent Grey, <Unnamed>
Type - Autre - Catégorie: Equipement de génie climatique; Nom de la famille: AI_Eqpmt genie clim_Préparateur instantané compact
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Pipe Diameter: 10 mm
Type - Données d'identification - Nom du type: AI_Eqpmt genie clim_Préparateur instantané compact; Sous-projet: Famille : Equipement de génie climatique : AI_Eqpmt genie clim_Préparateur instantané compact
Type - Matériaux et finitions - Logo material: Stiebel Eltron - Logo - DCE; Main material: Stiebel Eltron - Plastic - White; Material Cover: Stiebel Eltron - Plastic - White; Material of the water connections: Stiebel Eltron - Metal - Chrome
Type - Génie climatique - Classification: Aucun
Pset_DistributionFlowElementCommon - Reference: AI_Eqpmt genie clim_Préparateur instantané compact; sets with these values: 2
Autre - Famille: AI_Eqpmt genie clim_Préparateur instantané compact; Famille et type: AI_Eqpmt genie clim_Préparateur instantané compact: AI_Eqpmt genie clim_Préparateur instantané compact; ID du type: 936566; Type: AI_Eqpmt genie clim_Préparateur instantané compact
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - Surface: 0.00457977 m2; Volume: 0.0000167005 m3
Données d'identification - Sous-projet: 03_PLB
Génie climatique - Classification du système: Eau chaude sanitaire,Eau froide sanitaire
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Eqpmt genie clim_Préparateur instantané compact:AI_Eqpmt genie clim_Préparateur instantané compact:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant | Nom du système | Group
936704 | 1200 | 47 | EC 1,EF 1 | EC 1; EF 1
937593 | 361.718 | 49 | EC 3,EF 1 | EF 1; EC 3
938267 | 1200 | 50 | EC 2,EF 1 | EF 1; EC 2

# IfcFlowTerminal: AI_Eqpmt genie clim_Unité extérieure de climatisation:AI_Eqpmt genie clim_Unité extérieure de climatisation (4)
In: RDC
Type - Material: Metal - Steel, Galvanized, Finish.Cream, Plastique - Gris fonçé
Type - Autre - Catégorie: Equipement de génie climatique; Nom de la famille: AI_Eqpmt genie clim_Unité extérieure de climatisation
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: AI_Eqpmt genie clim_Unité extérieure de climatisation; Sous-projet: Famille : Equipement de génie climatique : AI_Eqpmt genie clim_Unité extérieure de climatisation
Type - Génie climatique - Classification: Aucun
Pset_DistributionFlowElementCommon - Reference: AI_Eqpmt genie clim_Unité extérieure de climatisation; sets with these values: 2
Autre - Famille: AI_Eqpmt genie clim_Unité extérieure de climatisation; Famille et type: AI_Eqpmt genie clim_Unité extérieure de climatisation: AI_Eqpmt genie clim_Unité extérieure de climatisation; ID du type: 892209; Type: AI_Eqpmt genie clim_Unité extérieure de climatisation
Contraintes - Hôte: Niveau : R-1; Niveau: R-1
Cotes - AI_Décalage symbole vertical: 0 mm; Surface: 1.60221 m2; Volume: 0.0726837 m3
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Classification du système: Puissance
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Eqpmt genie clim_Unité extérieure de climatisation:AI_Eqpmt genie clim_Unité extérieure de climatisation:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant
892218 | 1500 | 28
905269 | 1500 | 31
943617 | 1680 | 52 | Données d'identification - AI_Phase: EXISTANT
943650 | 980 | 53 | Données d'identification - AI_Phase: EXISTANT

# IfcFlowTerminal: AI_Eqpmt genie clim_Unité intérieure de climatisation:AI_Eqpmt genie clim_Unité intérieure de climatisation (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Equipement de génie climatique; Nom de la famille: AI_Eqpmt genie clim_Unité intérieure de climatisation
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: AI_Eqpmt genie clim_Unité intérieure de climatisation; Numéro OmniClass: 23.75.00.00; Sous-projet: Famille : Equipement de génie climatique : AI_Eqpmt genie clim_Unité intérieure de climatisation; Titre OmniClass: Climate Control (HVAC)
Type - Génie climatique - Classification: Aucun
Pset_DistributionFlowElementCommon - Reference: AI_Eqpmt genie clim_Unité intérieure de climatisation; sets with these values: 2
Autre - Famille: AI_Eqpmt genie clim_Unité intérieure de climatisation; Famille et type: AI_Eqpmt genie clim_Unité intérieure de climatisation: AI_Eqpmt genie clim_Unité intérieure de climatisation; ID du type: 851373; Type: AI_Eqpmt genie clim_Unité intérieure de climatisation
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2480 mm; Élévation par rapport au niveau: 2480 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.592363 m2; Volume: 0.0673549 m3
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Classification du système: Puissance
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Eqpmt genie clim_Unité intérieure de climatisation:AI_Eqpmt genie clim_Unité intérieure de climatisation:...) | Identifiant
889608 | 26
926439 | 42

# IfcFlowTerminal: AI_Instal elec_Brasseur d'air:AI_Instal elec_Brasseur d'air (23)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Installations électriques; Nom de la famille: AI_Instal elec_Brasseur d'air
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Diamètre Equipement: 1320 mm
Type - Données d'identification - Nom du type: AI_Instal elec_Brasseur d'air; Numéro OmniClass: 23.80.00.00; Sous-projet: Famille : Installations électriques : AI_Instal elec_Brasseur d'air; Titre OmniClass: Electric Power and Lighting
Pset_DistributionFlowElementCommon - Reference: AI_Instal elec_Brasseur d'air; sets with these values: 2
Autre - Famille: AI_Instal elec_Brasseur d'air; Famille et type: AI_Instal elec_Brasseur d'air: AI_Instal elec_Brasseur d'air; ID du type: 847866; Type: AI_Instal elec_Brasseur d'air
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2500 mm; Élévation par rapport au niveau: 2500 mm; Hôte: Niveau : RDC
Cotes - AI_Hauteur Equipement: 480 mm; Surface: 0.523171 m2; Volume: 0.0151075 m3
Electricité - Circuit - Données électriques: 0 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Instal elec_Brasseur d'air:AI_Instal elec_Brasseur d'air:...) | Identifiant
848317 | 4
861204 | 6
861221 | 7
861232 | 8
861243 | 9
1176224 | 689
1176458 | 690
1176606 | 691
1176607 | 692
1176637 | 693
1176638 | 694
1176734 | 695
1176735 | 696
1176806 | 697
1177532 | 698
1177580 | 699
1177635 | 700
1177878 | 702
1177920 | 703
1177996 | 704
1228180 | 707
1228207 | 708
1234528 | 709

# IfcFlowTerminal: AI_Instal elec_PC 16A +T à 0,30m:PC 16A +T à 0,30m (28)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Installations électriques; Nom de la famille: AI_Instal elec_PC 16A +T à 0,30m
Type - Contraintes - Elévation par défaut: 300 mm
Type - Cotes - H: 85 mm; H12: 31.5 mm; H3: 25 mm; L: 85 mm; L1: 63 mm; L12: 31.5 mm; L2D: 85 mm; L3: 25 mm; W2: 15 mm; W2D: 43 mm; W3: 10 mm; W3__ve: -10 mm
Type - Electrique - MC Active Power: 0 W; MC CosPhi: 1; MC Number of Poles: 1; MC Voltage: 230 V
Type - Données d'identification - Commentaires du type: Courants Forts; Description: PC ET; magiProductCode: Prise 2P+T étanche; Nom du type: PC 16A +T à 0,30m; Note d'identification: 19.02.05; Sous-projet: Famille : Installations électriques : AI_Instal elec_PC 16A +T à 0,30m
Type - Visibilité - AI_Visibilité_Applique: yes; AI_Visibilité_Sol: no
Pset_DistributionFlowElementCommon - Reference: PC 16A +T à 0,30m; sets with these values: 2
Autre - Famille: AI_Instal elec_PC 16A +T à 0,30m; Famille et type: AI_Instal elec_PC 16A +T à 0,30m: PC 16A +T à 0,30m; ID du type: 1051747; Type: PC 16A +T à 0,30m
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - AI_Décalage symbole vertical: 0 mm; AI_Décalage symbole horizontal: 0 mm; ang2D: 0 deg; dX2D: 0 mm; dY2D: 0 mm; Surface: 0.00706665 m2; Volume: 0.0000156045 m3
Electrique - MC Load: 0 W
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE; AI_Preneur: SHLMR
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Instal elec_PC 16A +T à 0,30m:PC 16A +T à 0,30m:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | AI_Visibilité symbole | Identifiant | Group
1159905 | 300 | no | 608 | Groupe de modèles:AI_Modèle_ELE PT1 a:1159911
1159906 | 300 | no | 24 | Groupe de modèles:AI_Modèle_ELE PT1 a:1159911
1160071 | 300 | no | 609 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160077
1160072 | 300 | no | 610 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160077
1160225 | 300 | no | 615 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160231
1160226 | 300 | no | 616 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160231
1160328 | 300 | no | 621 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160334
1160329 | 300 | no | 622 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160334
1160389 | 300 | no | 627 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160395
1160390 | 300 | no | 628 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160395
1160486 | 300 | no | 633 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160492
1160487 | 300 | no | 634 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160492
1160978 | 575 | no | 682 | Groupe de modèles:AI_Modèle_ELE PT1 V a:1160968
1160979 | 490 | no | 683 | Groupe de modèles:AI_Modèle_ELE PT1 V a:1160968
1161099 | 300 | no | 645 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161105
1161100 | 300 | no | 646 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161105
1161214 | 300 | no | 651 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161220
1161215 | 300 | no | 652 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161220
1161312 | 300 | no | 657 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161318
1161313 | 300 | no | 658 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161318
1161366 | 300 | no | 663 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161372
1161367 | 300 | no | 664 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161372
1161451 | 300 | no | 669 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161457
1161452 | 300 | no | 670 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161457
1161505 | 300 | no | 676 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161511
1161506 | 300 | no | 677 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161511
1161731 | 300 | yes | 687
1161739 | 300 | yes | 688

# IfcFlowTerminal: AI_Instal elec_Prise RJ45:RJ 45 Murale (26)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Installations électriques; Nom de la famille: AI_Instal elec_Prise RJ45
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - H: 85 mm; H12: 31.5 mm; H3: 25 mm; L: 85 mm; L1: 63 mm; L12: 31.5 mm; L2D: 85 mm; L3: 25 mm; W2: 15 mm; W2D: 43 mm; W3: 10 mm; W3__ve: -10 mm
Type - Electrique - MC CosPhi: 1; MC Number of Poles: 1; MC Active Power: 0 W; MC Voltage: 230 V
Type - Données d'identification - Commentaires du type: Courants Forts; Description: PC ET; magiProductCode: Prise 2P+T étanche; Nom du type: RJ 45 Murale; Note d'identification: 19.02.05; Sous-projet: Famille : Installations électriques : AI_Instal elec_Prise RJ45
Type - Visibilité - AI_Visibilité_Sol: no; AI_Visibilité_Murale: yes; AI_Visibilité_Plafond: no
Pset_DistributionFlowElementCommon - Reference: RJ 45 Murale; sets with these values: 2
Autre - Famille: AI_Instal elec_Prise RJ45; Famille et type: AI_Instal elec_Prise RJ45: RJ 45 Murale; ID du type: 1051718; Type: RJ 45 Murale
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - AI_Décalage symbole vertical: 0 mm; AI_Décalage symbole horizontal: 0 mm; AI_Visibilité symbole: no; ang2D: 0 deg; dX2D: 0 mm; dY2D: 0 mm; Surface: 0.0126164 m2; Volume: 0.0000265327 m3
Electrique - MC Load: 0 W
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE; AI_Preneur: SHLMR
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Instal elec_Prise RJ45:RJ 45 Murale:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant | Group
1159909 | 300 | 27 | Groupe de modèles:AI_Modèle_ELE PT1 a:1159911
1159910 | 300 | 28 | Groupe de modèles:AI_Modèle_ELE PT1 a:1159911
1160075 | 300 | 613 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160077
1160076 | 300 | 614 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160077
1160229 | 300 | 619 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160231
1160230 | 300 | 620 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160231
1160332 | 300 | 625 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160334
1160333 | 300 | 626 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160334
1160393 | 300 | 631 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160395
1160394 | 300 | 632 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160395
1160490 | 300 | 637 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160492
1160491 | 300 | 638 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160492
1160977 | 150 | 671 | Groupe de modèles:AI_Modèle_ELE PT1 V a:1160968
1160982 | 235 | 686 | Groupe de modèles:AI_Modèle_ELE PT1 V a:1160968
1161103 | 300 | 649 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161105
1161104 | 300 | 650 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161105
1161218 | 300 | 655 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161220
1161219 | 300 | 656 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161220
1161316 | 300 | 661 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161318
1161317 | 300 | 662 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161318
1161370 | 300 | 667 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161372
1161371 | 300 | 668 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161372
1161455 | 300 | 674 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161457
1161456 | 300 | 675 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161457
1161509 | 300 | 680 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161511
1161510 | 300 | 681 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161511

# IfcFlowTerminal: AI_Instal elec_Prise RJ45:RJ45 Plafonnière (3)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Installations électriques; Nom de la famille: AI_Instal elec_Prise RJ45
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - H: 85 mm; H12: 31.5 mm; H3: 25 mm; L: 85 mm; L1: 63 mm; L12: 31.5 mm; L2D: 85 mm; L3: 25 mm; W2: 15 mm; W2D: 43 mm; W3: 10 mm; W3__ve: -10 mm
Type - Electrique - MC CosPhi: 1; MC Number of Poles: 1; MC Active Power: 0 W; MC Voltage: 230 V
Type - Données d'identification - Sous-projet: Famille : Installations électriques : AI_Instal elec_Prise RJ45; Commentaires du type: Courants Forts; Description: PC ET; magiProductCode: Prise 2P+T étanche; Nom du type: RJ45 Plafonnière; Note d'identification: 19.02.05
Type - Visibilité - AI_Visibilité_Sol: no; AI_Visibilité_Murale: no; AI_Visibilité_Plafond: yes
Pset_DistributionFlowElementCommon - Reference: RJ45 Plafonnière; sets with these values: 2
Autre - Famille: AI_Instal elec_Prise RJ45; Famille et type: AI_Instal elec_Prise RJ45: RJ45 Plafonnière; ID du type: 1051719; Type: RJ45 Plafonnière
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2980 mm; Élévation par rapport au niveau: 2980 mm; Hôte: Niveau : RDC
Cotes - AI_Décalage symbole vertical: 0 mm; AI_Décalage symbole horizontal: 0 mm; ang2D: 0 deg; dX2D: 0 mm; dY2D: 0 mm; AI_Visibilité symbole: yes; Surface: 0.0126164 m2; Volume: 0.0000265328 m3
Electrique - MC Load: 0 W
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE; AI_Preneur: SHLMR
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Instal elec_Prise RJ45:RJ45 Plafonnière:...) | Identifiant
1196424 | 4034
1196605 | 705
1196627 | 706

# IfcFlowTerminal: AI_Instal elec_Prise de courant 2P+T 16A ondulée:AI_Instal elec_Prise de courant 2P+T 16A ondulée (26)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Installations électriques; Nom de la famille: AI_Instal elec_Prise de courant 2P+T 16A ondulée
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - H: 85 mm; H12: 31.5 mm; H3: 25 mm; L: 85 mm; L1: 63 mm; L12: 31.5 mm; L2D: 85 mm; L3: 25 mm; W2: 15 mm; W2D: 43 mm; W3: 10 mm; W3__ve: -10 mm
Type - Electrique - MC CosPhi: 1; MC Number of Poles: 1; MC Active Power: 0 W; MC Voltage: 230 V
Type - Données d'identification - Commentaires du type: Courants Forts; Description: PC ET; magiProductCode: Prise 2P+T étanche; Nom du type: AI_Instal elec_Prise de courant 2P+T 16A ondulée; Note d'identification: 19.02.05; Sous-projet: Famille : Installations électriques : AI_Instal elec_Prise de courant 2P+T 16A ondulée
Type - Visibilité - AI_Visibilité_Applique: yes; AI_Visibilité_Sol: no
Pset_DistributionFlowElementCommon - Reference: AI_Instal elec_Prise de courant 2P+T 16A ondulée; sets with these values: 2
Autre - Famille: AI_Instal elec_Prise de courant 2P+T 16A ondulée; Famille et type: AI_Instal elec_Prise de courant 2P+T 16A ondulée: AI_Instal elec_Prise de courant 2P+T 16A ondulée; ID du type: 1051759; Type: AI_Instal elec_Prise de courant 2P+T 16A ondulée
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - AI_Décalage symbole vertical: 0 mm; AI_Décalage symbole horizontal: 0 mm; AI_Visibilité symbole: no; ang2D: 0 deg; dX2D: 0 mm; dY2D: 0 mm; Surface: 0.00706665 m2; Volume: 0.0000156045 m3
Electrique - MC Load: 0 W
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE; AI_Preneur: SHLMR
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Instal elec_Prise de courant 2P+T 16A ondulée:AI_Instal elec_Prise de courant 2P+T 16A ondulée:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant | Group
1159907 | 300 | 25 | Groupe de modèles:AI_Modèle_ELE PT1 a:1159911
1159908 | 300 | 26 | Groupe de modèles:AI_Modèle_ELE PT1 a:1159911
1160073 | 300 | 611 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160077
1160074 | 300 | 612 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160077
1160227 | 300 | 617 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160231
1160228 | 300 | 618 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160231
1160330 | 300 | 623 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160334
1160331 | 300 | 624 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160334
1160391 | 300 | 629 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160395
1160392 | 300 | 630 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160395
1160488 | 300 | 635 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160492
1160489 | 300 | 636 | Groupe de modèles:AI_Modèle_ELE PT1 a:1160492
1160980 | 405 | 684 | Groupe de modèles:AI_Modèle_ELE PT1 V a:1160968
1160981 | 320 | 685 | Groupe de modèles:AI_Modèle_ELE PT1 V a:1160968
1161101 | 300 | 647 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161105
1161102 | 300 | 648 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161105
1161216 | 300 | 653 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161220
1161217 | 300 | 654 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161220
1161314 | 300 | 659 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161318
1161315 | 300 | 660 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161318
1161368 | 300 | 665 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161372
1161369 | 300 | 666 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161372
1161453 | 300 | 672 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161457
1161454 | 300 | 673 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161457
1161507 | 300 | 678 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161511
1161508 | 300 | 679 | Groupe de modèles:AI_Modèle_ELE PT1 a:1161511

# IfcFlowTerminal: AI_Luminaire_BAES:BAES (3)
In: RDC
Type - Material: <Unnamed>, Plastic, PVC, Flexible
Type - Autre - Catégorie: Luminaires; 1633: no; 1634: no; Down: no; Down Right: no; Left Exit EU: no; Right Man: no; Right Up: no; Up Left Exit: no; Up Right: no; Exit: no; Left Man: yes; Nom de la famille: AI_Luminaire_BAES; Right Exit EU: yes
Type - Contraintes - Elévation par défaut: 0 mm
Type - Construction - Emergency Signs: Emergency Signs : RTD1628
Type - Cotes - Taille du symbole de la source d'éclairage: 609.6 mm; AI_Hauteur Equipement: 80 mm; AI_Largeur Equipement: 80 mm; AI_Longueur Equipement: 240 mm
Type - Données d'identification - Sous-projet: Famille : Luminaires : AI_Luminaire_BAES; Nom du type: BAES; Numéro OmniClass: 23.80.70.00; Titre OmniClass: Lighting
Type - Photométriques - Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Emettre à partir de la longueur de la ligne: 609.6 mm; Définition de la source d'éclairage (famille): Ligne+Sphérique; Eclairement: 20.5576 lx; Efficacité: 148.542 s3*lm/kg/m2; Filtre de couleur: 16777215; Flux lumineux: 2400 lm; Intensité lumineuse: 190.986 cd; Puissance: 16.1571 W; Température initiale des couleurs: 3000 K
Type - Matériaux et finitions - Primary material: PVC, Flexible; Secondary material: Plastic
Type - Visibilité - AI_BAES_AMB: no; AI_BAES_ES1: no; AI_BAES_ES3: no; AI_BAES_Grille: no; AI_BAES_Flèche: yes; AI_BAES_Sortie: no
Pset_DistributionFlowElementCommon - Reference: BAES; sets with these values: 2
Autre - Famille: AI_Luminaire_BAES; Famille et type: AI_Luminaire_BAES: BAES; ID du type: 1152564; Type: BAES
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - AI_Décalage symbole vertical: 0 mm; Surface: 1.25705 m2; Volume: 0.300629 m3
Electricité - Circuit - Données électriques: 0 V/1-0 VA
Electricité - Eclairage - Calculer le coefficient d'utilisation: no
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_BAES:BAES:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant
1196318 | 2707.44 | 141
1196373 | 2707.44 | 142
1196763 | 2630.45 | 145

# IfcFlowTerminal: AI_Luminaire_BAES:Sortie (7)
In: RDC
Type - Material: <Unnamed>, PVC, Flexible, Plastic
Type - Autre - Catégorie: Luminaires; 1633: no; 1634: no; Down: no; Down Right: no; Exit: yes; Left Exit EU: no; Left Man: no; Nom de la famille: AI_Luminaire_BAES; Right Exit EU: no; Right Man: no; Right Up: no; Up Left Exit: no; Up Right: no
Type - Contraintes - Elévation par défaut: 0 mm
Type - Construction - Emergency Signs: Emergency Signs : RTD1628
Type - Cotes - AI_Hauteur Equipement: 80 mm; AI_Largeur Equipement: 80 mm; AI_Longueur Equipement: 240 mm; Taille du symbole de la source d'éclairage: 609.6 mm
Type - Données d'identification - Nom du type: Sortie; Numéro OmniClass: 23.80.70.00; Sous-projet: Famille : Luminaires : AI_Luminaire_BAES; Titre OmniClass: Lighting
Type - Photométriques - Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Emettre à partir de la longueur de la ligne: 609.6 mm; Définition de la source d'éclairage (famille): Ligne+Sphérique; Eclairement: 20.5576 lx; Efficacité: 148.542 s3*lm/kg/m2; Filtre de couleur: 16777215; Flux lumineux: 2400 lm; Intensité lumineuse: 190.986 cd; Puissance: 16.1571 W; Température initiale des couleurs: 3000 K
Type - Matériaux et finitions - Primary material: PVC, Flexible; Secondary material: Plastic
Type - Visibilité - AI_BAES_AMB: no; AI_BAES_ES1: no; AI_BAES_ES3: no; AI_BAES_Flèche: no; AI_BAES_Grille: no; AI_BAES_Sortie: yes
Pset_DistributionFlowElementCommon - Reference: Sortie; sets with these values: 2
Autre - Famille: AI_Luminaire_BAES; Famille et type: AI_Luminaire_BAES: Sortie; ID du type: 1152563; Type: Sortie
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - AI_Décalage symbole vertical: 0 mm; Surface: 1.25705 m2; Volume: 0.300629 m3
Electricité - Circuit - Données électriques: 0 V/1-0 VA
Electricité - Eclairage - Calculer le coefficient d'utilisation: no
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_BAES:Sortie:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant
1195764 | 2300.45 | 134
1195799 | 2300.45 | 135
1195819 | 2420.45 | 136
1195857 | 2720.45 | 137
1196148 | 2420.45 | 138
1196192 | 2420.45 | 139
1196268 | 2420.45 | 140

# IfcFlowTerminal: AI_Luminaire_Borne WIFI:Plafond (3)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_Borne WIFI
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 60 mm; AI_Largeur Equipement: 200 mm; AI_Longueur Equipement: 200 mm
Type - Données d'identification - Nom du type: Plafond; Numéro OmniClass: 23.80.30.11.17; Sous-projet: Famille : Luminaires : AI_Luminaire_Borne WIFI; Titre OmniClass: Distribution Boards and Control Panels
Pset_DistributionFlowElementCommon - Reference: Plafond; sets with these values: 2
Autre - Famille: AI_Luminaire_Borne WIFI; Famille et type: AI_Luminaire_Borne WIFI: Plafond; ID du type: 1152551; Type: Plafond
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2920 mm; Élévation par rapport au niveau: 2920 mm; Hôte: Niveau : RDC
Cotes - AI_Décalage symbole vertical: 0 mm; AI_Décalage symbole horizontal: 165 mm; Surface: 0.064 m2; Volume: 0.0024 m3
Electricité - Circuit - Données électriques: 0 V/1-0 VA
Electricité - Eclairage - Calculer le coefficient d'utilisation: no
Données d'identification - Sous-projet: 02_ELE; AI_Preneur: SHLMR
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_Borne WIFI:Plafond:...) | Identifiant
1196423 | 1831
1196604 | 143
1196626 | 144

# IfcFlowTerminal: AI_Luminaire_CONCEPT S_Angle:CONCEPTION O (3)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_CONCEPT S_Angle
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 56 mm; AI_Largeur Equipement: 175 mm
Type - Données d'identification - Nom du type: CONCEPTION O; Numéro OmniClass: 23.80.70.00; Sous-projet: Famille : Luminaires : AI_Luminaire_CONCEPT S_Angle; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Emettre à partir de la longueur de la ligne: 609.6 mm; Fichier de distribution photométrique: 1x41T12.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: CONCEPTION O; sets with these values: 2
Autre - Famille: AI_Luminaire_CONCEPT S_Angle; Famille et type: AI_Luminaire_CONCEPT S_Angle: CONCEPTION O; ID du type: 1177146; Type: CONCEPTION O
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2660 mm; Élévation par rapport au niveau: 2660 mm; Hôte: Niveau : RDC
Cotes - AI_Angle Equipement: 360 deg; AI_Rayon Equipement: 675 mm; Surface: 0.892602 m2; Volume: 0.0378662 m3
Electricité - Circuit - Données électriques: 0 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_CONCEPT S_Angle:CONCEPTION O:...) | Identifiant
1176977 | 55
1178285 | 56
1178637 | 57

# IfcFlowTerminal: AI_Luminaire_CONCEPT S_Angle:CONCEPTION S (4)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_CONCEPT S_Angle
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 56 mm; AI_Largeur Equipement: 55 mm
Type - Données d'identification - Sous-projet: Famille : Luminaires : AI_Luminaire_CONCEPT S_Angle; Nom du type: CONCEPTION S; Numéro OmniClass: 23.80.70.00; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Emettre à partir de la longueur de la ligne: 609.6 mm; Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Fichier de distribution photométrique: 1x41T12.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: CONCEPTION S; sets with these values: 2
Autre - Famille: AI_Luminaire_CONCEPT S_Angle; Type: CONCEPTION S; Famille et type: AI_Luminaire_CONCEPT S_Angle: CONCEPTION S; ID du type: 1165759
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - AI_Angle Equipement: 180 deg; AI_Rayon Equipement: 1250 mm; Surface: 0.434878 m2; Volume: 0.0119966 m3
Electricité - Circuit - Données électriques: 0 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_CONCEPT S_Angle:CONCEPTION S:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant
1234153 | 2760 | 165
1234173 | 2660 | 166
1234189 | 2760 | 167
1234220 | 2560 | 168

# IfcFlowTerminal: AI_Luminaire_CONCEPT S_Linéaire:CONCEPTION S (7)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_CONCEPT S_Linéaire
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 56 mm; AI_Largeur Equipement: 55 mm
Type - Données d'identification - Nom du type: CONCEPTION S; Numéro OmniClass: 23.80.70.00; Sous-projet: Famille : Luminaires : AI_Luminaire_CONCEPT S_Linéaire; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Emettre à partir de la largeur du rectangle: 609.6 mm; Emettre à partir de la longueur du rectangle: 1219.2 mm; Emettre la visibilité des formes dans le rendu: no; Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Définition de la source d'éclairage (famille): Rectangle+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Fichier de distribution photométrique: 1x41T12.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: CONCEPTION S; sets with these values: 2
Autre - Famille: AI_Luminaire_CONCEPT S_Linéaire; Famille et type: AI_Luminaire_CONCEPT S_Linéaire: CONCEPTION S; ID du type: 1163224; Type: CONCEPTION S
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_CONCEPT S_Linéaire:CONCEPTION S:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | AI_Longueur Equipement (mm) | Surface (m2) | Volume (m3) | Identifiant
1187620 | 2733.71 | 6605.47 | 0.736287 | 0.0203448 | 95 | Données d'identification - Modifié par: christophe.sautron
1187769 | 2733.71 | 18604.5 | 2.06818 | 0.0573018 | 96
1187840 | 2733.71 | 3799.42 | 0.424816 | 0.0117022 | 97
1188031 | 2733.71 | 5633.7 | 0.62842 | 0.0173518 | 98
1188375 | 2693.71 | 9321.34 | 1.03775 | 0.0287097 | 99
1188670 | 2733.71 | 9140.29 | 1.01765 | 0.0281521 | 100
1194887 | 2733.71 | 5633.7 | 0.62842 | 0.0173518 | 132

# IfcFlowTerminal: AI_Luminaire_Circulaire plafonnier:A2, AI_Luminaire_Circulaire plafonnier:A2:1184840
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_Circulaire plafonnier
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Diamètre Equipement: 850 mm; AI_Hauteur Equipement: 50 mm; AI_Rayon Equipement: 425 mm
Type - Données d'identification - Sous-projet: Famille : Luminaires : AI_Luminaire_Circulaire plafonnier; Nom du type: A2; Numéro OmniClass: 23.80.70.00; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Définition de la source d'éclairage (famille): Point+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Fichier de distribution photométrique: CLFR1A21.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: A2; sets with these values: 2
Autre - Famille: AI_Luminaire_Circulaire plafonnier; Famille et type: AI_Luminaire_Circulaire plafonnier: A2; ID du type: 1184851; Type: A2
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2710 mm; Élévation par rapport au niveau: 2710 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.634197 m2; Volume: 0.0283724 m3
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE; Identifiant: 92
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowTerminal: AI_Luminaire_Circulaire plafonnier:A5 (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_Circulaire plafonnier
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Diamètre Equipement: 600 mm; AI_Hauteur Equipement: 50 mm; AI_Rayon Equipement: 300 mm
Type - Données d'identification - Nom du type: A5; Numéro OmniClass: 23.80.70.00; Sous-projet: Famille : Luminaires : AI_Luminaire_Circulaire plafonnier; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Définition de la source d'éclairage (famille): Point+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Fichier de distribution photométrique: CLFR1A21.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: A5; sets with these values: 2
Autre - Famille: AI_Luminaire_Circulaire plafonnier; Famille et type: AI_Luminaire_Circulaire plafonnier: A5; ID du type: 1152582; Type: A5
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2710 mm; Élévation par rapport au niveau: 2710 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.329856 m2; Volume: 0.014137 m3
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_Circulaire plafonnier:A5:...) | Identifiant
1181527 | 90 | Electricité - Charges - Numero de circuit: <sans nom>
1184762 | 91

# IfcFlowTerminal: AI_Luminaire_Circulaire suspendu:A6 (8)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_Circulaire suspendu
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - A: 180 mm; AI_Diamètre Equipement: 65 mm; AI_Hauteur Equipement: 350 mm; AI_Rayon Equipement: 32.5 mm
Type - Données d'identification - Nom du type: A6; Numéro OmniClass: 23.80.70.00; Sous-projet: Famille : Luminaires : AI_Luminaire_Circulaire suspendu; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Définition de la source d'éclairage (famille): Point+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Fichier de distribution photométrique: CLFR1A21.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: A6; sets with these values: 2
Autre - Famille: AI_Luminaire_Circulaire suspendu; Famille et type: AI_Luminaire_Circulaire suspendu: A6; ID du type: 1190750; Type: A6
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2980 mm; Élévation par rapport au niveau: 2980 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.0321109 m2; Volume: 0.000750004 m3
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_Circulaire suspendu:A6:...) | Identifiant
1194219 | 107
1194253 | 108
1194263 | 109
1194271 | 110
1194279 | 111
1228008 | 148
1228036 | 149
1228044 | 150

# IfcFlowTerminal: AI_Luminaire_Linéaire avec suspente:A7 (20)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_Linéaire avec suspente
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 65 mm; AI_Largeur Equipement: 40 mm; AI_Longueur Equipement: 600 mm
Type - Données d'identification - Nom du type: A7; Numéro OmniClass: 23.80.70.00; Sous-projet: Famille : Luminaires : AI_Luminaire_Linéaire avec suspente; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Définition de la source d'éclairage (famille): Rectangle+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Emettre à partir de la largeur du rectangle: 609.6 mm; Emettre à partir de la longueur du rectangle: 1219.2 mm; Emettre la visibilité des formes dans le rendu: no; Facteur de perte de luminosité totale: 1; Fichier de distribution photométrique: 1x41T12.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Gradation des changements de température de couleur de lampe: <Aucun>; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: A7; sets with these values: 2
Autre - Famille: AI_Luminaire_Linéaire avec suspente; Famille et type: AI_Luminaire_Linéaire avec suspente: A7; ID du type: 846735; Type: A7
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2680 mm; Élévation par rapport au niveau: 2680 mm; Hôte: Niveau : RDC
Cotes - AI_Hauteur suspente: 300 mm; Surface: 0.0850778 m2; Volume: 0.00174849 m3
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_Linéaire avec suspente:A7:...) | Identifiant
861205 | 13
1181137 | 70
1181183 | 71
1181184 | 72
1181409 | 74
1181410 | 75
1181411 | 76
1181412 | 77
1181438 | 78
1181439 | 79
1181440 | 80
1181441 | 81
1181474 | 82
1181475 | 83
1181476 | 84
1181477 | 85
1181493 | 86
1181494 | 87
1181495 | 88
1181496 | 89

# IfcFlowTerminal: AI_Luminaire_Linéaire avec suspente:A9 (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_Linéaire avec suspente
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 50 mm; AI_Largeur Equipement: 110 mm; AI_Longueur Equipement: 1450 mm
Type - Données d'identification - Sous-projet: Famille : Luminaires : AI_Luminaire_Linéaire avec suspente; Nom du type: A9; Numéro OmniClass: 23.80.70.00; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Emettre à partir de la largeur du rectangle: 609.6 mm; Emettre à partir de la longueur du rectangle: 1219.2 mm; Emettre la visibilité des formes dans le rendu: no; Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Définition de la source d'éclairage (famille): Rectangle+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Fichier de distribution photométrique: 1x41T12.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: A9; sets with these values: 2
Autre - Famille: AI_Luminaire_Linéaire avec suspente; Famille et type: AI_Luminaire_Linéaire avec suspente: A9; ID du type: 1187361; Type: A9
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2680 mm; Élévation par rapport au niveau: 2680 mm; Hôte: Niveau : RDC
Cotes - AI_Hauteur suspente: 300 mm; Surface: 0.256978 m2; Volume: 0.00816349 m3
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_Linéaire avec suspente:A9:...) | Identifiant
1181291 | 73
1187469 | 94

# IfcFlowTerminal: AI_Luminaire_Réglette locaux techniques et parkings:C1 (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_Réglette locaux techniques et parkings
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 90 mm; AI_Largeur Equipement: 195 mm; AI_Longueur Equipement: 1550 mm
Type - Données d'identification - Nom du type: C1; Numéro OmniClass: 23.80.70.00; Sous-projet: Famille : Luminaires : AI_Luminaire_Réglette locaux techniques et parkings; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Emettre à partir de la largeur du rectangle: 609.6 mm; Emettre à partir de la longueur du rectangle: 1219.2 mm; Emettre la visibilité des formes dans le rendu: no; Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Définition de la source d'éclairage (famille): Rectangle+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Fichier de distribution photométrique: 1x41T12.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: C1; sets with these values: 2
Autre - Famille: AI_Luminaire_Réglette locaux techniques et parkings; Famille et type: AI_Luminaire_Réglette locaux techniques et parkings: C1; ID du type: 1152557; Type: C1
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2500 mm; Élévation par rapport au niveau: 2500 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.4593 m2; Volume: 0.0272025 m3
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_Réglette locaux techniques et parkings:C1:...) | Identifiant
1179533 | 68
1179626 | 69

# IfcFlowTerminal: AI_Luminaire_Réglette sanitaire:Reglette (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_Réglette sanitaire
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Reglette; Numéro OmniClass: 23.80.70.00; Sous-projet: Famille : Luminaires : AI_Luminaire_Réglette sanitaire; Titre OmniClass: Lighting
Type - Photométriques - Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Emettre à partir de la longueur de la ligne: 609.6 mm; Angle de l'inclinaison: 60 deg; Définition de la source d'éclairage (famille): Ligne+Distribution photométrique; Eclairement: 11.9919 lx; Efficacité: 148.542 s3*lm/kg/m2; Fichier de distribution photométrique: generic; Filtre de couleur: 16777215; Flux lumineux: 1400 lm; Intensité lumineuse: 111.408 cd; Puissance: 9.42495 W; Température initiale des couleurs: 3000 K
Type - Visibilité - Réglette: yes; Réglette + PC: no
Pset_DistributionFlowElementCommon - Reference: Reglette; sets with these values: 2
Autre - Famille: AI_Luminaire_Réglette sanitaire; Famille et type: AI_Luminaire_Réglette sanitaire: Reglette; ID du type: 1152543; Type: Reglette
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2260 mm; Élévation par rapport au niveau: 2260 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.0725 m2; Volume: 0.00175 m3
Electricité - Circuit - Données électriques: 0 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_Réglette sanitaire:Reglette:...) | Identifiant
1214315 | 146
1214325 | 147

# IfcFlowTerminal: AI_Luminaire_Spot Downlight:A3 (26)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_Spot Downlight
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Diamètre Equipement: 240 mm; AI_Hauteur Equipement: 90 mm; AI_Rayon Equipement: 120 mm
Type - Données d'identification - Sous-projet: Famille : Luminaires : AI_Luminaire_Spot Downlight; Nom du type: A3; Numéro OmniClass: 23.80.70.00; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Définition de la source d'éclairage (famille): Point+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Fichier de distribution photométrique: CLFR1A21.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: A3; sets with these values: 2
Autre - Famille: AI_Luminaire_Spot Downlight; Famille et type: AI_Luminaire_Spot Downlight: A3; ID du type: 849956; Type: A3
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - Surface: 0.0791621 m2; Volume: 0.00407131 m3
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_Spot Downlight:A3:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant
1194335 | 2600 | 112
1194611 | 2600 | 113
1194713 | 2800 | 114
1194716 | 2800 | 115
1194724 | 2700 | 116
1194727 | 2700 | 117
1194741 | 2700 | 118
1194744 | 2700 | 119
1194754 | 2700 | 120
1194757 | 2700 | 121
1194765 | 2600 | 122
1194768 | 2600 | 123
1194789 | 2780 | 126
1194792 | 2780 | 127
1194802 | 2600 | 128
1194805 | 2600 | 129
1194817 | 2700 | 130
1194820 | 2700 | 131
1228122 | 2600 | 151
1228123 | 2600 | 152
1228147 | 2700 | 153
1228148 | 2700 | 154
1228237 | 2600 | 155
1228238 | 2600 | 156
1228258 | 2600 | 157
1228259 | 2600 | 158

# IfcFlowTerminal: AI_Luminaire_Spot Downlight:A4 (9)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Luminaires; Nom de la famille: AI_Luminaire_Spot Downlight
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Diamètre Equipement: 240 mm; AI_Hauteur Equipement: 90 mm; AI_Rayon Equipement: 120 mm
Type - Données d'identification - Nom du type: A4; Numéro OmniClass: 23.80.70.00; Sous-projet: Famille : Luminaires : AI_Luminaire_Spot Downlight; Titre OmniClass: Lighting
Type - Photométriques - Angle de l'inclinaison: 90 deg; Facteur de perte de luminosité totale: 1; Gradation des changements de température de couleur de lampe: <Aucun>; Définition de la source d'éclairage (famille): Point+Distribution photométrique; Eclairement: 11.8206 lx; Efficacité: 148.542 s3*lm/kg/m2; Fichier de distribution photométrique: CLFR1A21.ies; Filtre de couleur: 16777215; Flux lumineux: 1380 lm; Intensité lumineuse: 109.817 cd; Puissance: 9.2903 W; Température initiale des couleurs: 3000 K
Pset_DistributionFlowElementCommon - Reference: A4; sets with these values: 2
Autre - Famille: AI_Luminaire_Spot Downlight; Famille et type: AI_Luminaire_Spot Downlight: A4; ID du type: 1178700; Type: A4
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - Surface: 0.0791621 m2; Volume: 0.00407131 m3
Electricité - Circuit - Données électriques: 230 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Luminaire_Spot Downlight:A4:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant
1178691 | 2500 | 58
1178899 | 2500 | 59
1178950 | 2500 | 60
1178951 | 2500 | 61
1178971 | 2500 | 62
1179196 | 2500 | 63
1179207 | 2500 | 64
1179236 | 2500 | 65
1184910 | 2610 | 93

# IfcGroup: Groupe de modèles:AI_Modèle_ELE PT1 V a, Groupe de modèles:AI_Modèle_ELE PT1 V a:1160968
Autre - Catégorie: Groupes de modèles; Famille: Groupe de modèles; Famille et type: Groupe de modèles: AI_Modèle_ELE PT1 V a; ID du type: 1051976; Type: AI_Modèle_ELE PT1 V a
Contraintes - Niveau de référence: RDC; Décalage du niveau de l'origine: -150 mm
Données d'identification - Sous-projet: 02_ELE
Autre(Type) - Catégorie: Groupes de modèles; Nom de la famille: Groupe de modèles
Données d'identification(Type) - Sous-projet: 02_ELE; Nom du type: AI_Modèle_ELE PT1 V a

# IfcGroup: Groupe de modèles:AI_Modèle_ELE PT1 a (12)
Autre - Catégorie: Groupes de modèles; Famille: Groupe de modèles; Famille et type: Groupe de modèles: AI_Modèle_ELE PT1 a; ID du type: 1153019; Type: AI_Modèle_ELE PT1 a
Contraintes - Décalage du niveau de l'origine: 0 mm; Niveau de référence: RDC
Données d'identification - Sous-projet: 02_ELE
Autre(Type) - Catégorie: Groupes de modèles; Nom de la famille: Groupe de modèles
Données d'identification(Type) - Sous-projet: 02_ELE; Nom du type: AI_Modèle_ELE PT1 a
Name (Groupe de modèles:AI_Modèle_ELE PT1 a:...)
1159911
1160077
1160231
1160334
1160395
1160492
1161105
1161220
1161318
1161372
1161457
1161511
