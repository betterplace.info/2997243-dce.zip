Properties of the parts of a building model (IFC2X3), part 5 of 8

# IfcFlowSegment: Canalisation:Acier - Té (134)
Name (Canalisation:Acier - Té:...) | Length (mm) = Longueur (mm) | Arase inférieure à son extrémité amont (mm) = Arase inférieure avec isolant à son extrémité amont (mm) | Arase inférieure à son extrémité aval (mm) = Arase inférieure avec isolant à son extrémité aval (mm) | Arase supérieure à son extrémité amont (mm) = Arase supérieure avec isolant à son extrémité amont (mm) | Arase supérieure à son extrémité aval (mm) = Arase supérieure avec isolant à son extrémité aval (mm) | Élévation centrale de départ (mm) = Elévation du milieu (mm) | Élévation centrale de fin (mm) | Elévation de l'axe à son extrémité amont (mm) | Elévation de l'axe à son extrémité aval (mm) | Elévation du fond (fil d'eau) à son extrémité amont (mm) | Elévation du fond (fil d'eau) à son extrémité aval (mm) | Elévation du point haut intérieur du tube à son extrémité amont (mm) | Elévation du point haut intérieur du tube à son extrémité aval (mm) | Niveau de référence | Diamètre extérieur (mm) | Diamètre intérieur (mm) | Epaisseur de paroi (mm) | Taille = Taille globale | Abréviation du système | Classification du système | Diamètre (mm) | Elévation du fond (fil d'eau) (mm) | Nom du système = Group | Surface (m2) | Type de système | Débit (m3/s) = Débit supplémentaire (m3/s) = Facteur de frottement = Frottement = Nombre de Reynolds = Perte de pression (Pa) = Pression dynamique (Pa) = Vitesse (m/s) | Etat du flux | Limite de boucle = Trajectoire critique | Rugosité relative | Tronçon
1065767 | 244.544 | 2845.46 | 2845.33 | 2887.62 | 2887.49 | 2866.41 | 2866.54 | 2866.54 | 2866.41 | 2849.02 | 2848.89 | 2884.07 | 2883.94 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2848.89 | EU 12 | 0.0245843 | 3.Condensats |  |  |  | 0.00130435 | 4 | Contraintes - Inclinaison: 0.000530609; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1065769 | 6564.95 | 2911.33 | 2845.68 | 2953.49 | 2887.84 | 2932.41 | 2866.76 | 2932.41 | 2866.76 | 2914.88 | 2849.24 | 2949.93 | 2884.29 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2849.24 | EU 12 | 0.659981 | 3.Condensats |  |  |  | 0.00130435 | 4 | Contraintes - Inclinaison: 0.01; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1065976 | 2682.99 | 2844.65 | 2804.41 | 2886.81 | 2846.57 | 2825.49 | 2865.73 | 2865.73 | 2825.49 | 2848.21 | 2807.97 | 2883.26 | 2843.01 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2807.97 | EU 12 | 0.269724 | 3.Condensats |  |  |  | 0.00130435 | 3 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1066150 | 1080.37 | 2821.81 | 2805.61 | 2863.97 | 2847.77 | 2842.89 | 2826.69 | 2842.89 | 2826.69 | 2825.37 | 2809.16 | 2860.42 | 2844.21 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2809.16 | EU 13 | 0.108611 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1066154 | 1051.8 | 2838.55 | 2822.77 | 2880.71 | 2864.93 | 2859.63 | 2843.85 | 2859.63 | 2843.85 | 2842.1 | 2826.33 | 2877.15 | 2861.38 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2826.33 | EU 13 | 0.105738 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1066390 | 219.986 | 2800.38 | 2797.08 | 2842.54 | 2839.24 | 2818.16 | 2821.46 | 2821.46 | 2818.16 | 2803.94 | 2800.64 | 2838.99 | 2835.69 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2800.64 | EU 14 | 0.0221154 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: FRIGO; Génie climatique - Débit - Débit par appareil: 0
1066392 | 4184.73 | 2864.11 | 2801.34 | 2906.27 | 2843.5 | 2822.42 | 2885.19 | 2885.19 | 2822.42 | 2867.66 | 2804.9 | 2902.71 | 2839.95 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2804.9 | EU 14 | 0.420695 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: FRIGO; Génie climatique - Débit - Débit par appareil: 0
1066394 | 3428 | 2916.48 | 2865.07 | 2958.64 | 2907.23 | 2886.15 | 2937.56 | 2937.56 | 2886.15 | 2920.04 | 2868.62 | 2955.08 | 2903.67 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2868.62 | EU 14 | 0.34462 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: FRIGO; Génie climatique - Débit - Débit par appareil: 0
1066404 | 312.597 | 2796.12 | 2791.43 | 2838.28 | 2833.59 | 2812.51 | 2817.2 | 2817.2 | 2812.51 | 2799.68 | 2794.99 | 2834.73 | 2830.04 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2794.99 | EU 14 | 0.0314256 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: FRIGO; Génie climatique - Débit - Débit par appareil: 0
1066522 | 4184.73 | 2827.95 | 2765.19 | 2870.11 | 2807.35 | 2786.27 | 2849.03 | 2849.03 | 2786.27 | 2831.51 | 2768.75 | 2866.56 | 2803.79 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2768.75 | EU 15 | 0.420695 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: FRIGO; Génie climatique - Débit - Débit par appareil: 0
1066524 | 5670.3 | 2913.96 | 2828.91 | 2956.12 | 2871.07 | 2849.99 | 2935.04 | 2935.04 | 2849.99 | 2917.51 | 2832.47 | 2952.56 | 2867.52 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2832.47 | EU 15 | 0.57004 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: FRIGO; Génie climatique - Débit - Débit par appareil: 0
1066587 | 60.1638 | 2764.23 | 2763.33 | 2806.39 | 2805.49 | 2784.41 | 2785.31 | 2785.31 | 2784.41 | 2767.79 | 2766.88 | 2802.83 | 2801.93 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2766.88 | EU 15 | 0.00604833 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: FRIGO; Génie climatique - Débit - Débit par appareil: 0
1066589 | 312.633 | 2762.37 | 2757.68 | 2804.53 | 2799.84 | 2778.76 | 2783.45 | 2783.45 | 2778.76 | 2765.92 | 2761.23 | 2800.97 | 2796.28 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2761.23 | EU 15 | 0.0314293 | 3.Condensats |  |  |  | 0.00130435 | 2 | Contraintes - Inclinaison: 0.015; Données d'identification - AI_Métré canalisation: FRIGO; Génie climatique - Débit - Débit par appareil: 0
1067396 | 5671.87 | 2911.36 | 2854.64 | 2953.52 | 2896.81 | 2932.44 | 2875.73 | 2932.44 | 2875.73 | 2914.92 | 2858.2 | 2949.97 | 2893.25 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2858.2 | EU 17 | 0.570198 | 3.Condensats |  |  |  | 0.00130435 | 3 | Contraintes - Inclinaison: 0.01; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1067746 | 3438.6 | 2889.83 | 2855.45 | 2932 | 2897.62 | 2910.91 | 2876.53 | 2910.91 | 2876.53 | 2893.39 | 2859.01 | 2928.44 | 2894.06 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2859.01 | EU 17 | 0.345686 | 3.Condensats |  |  |  | 0.00130435 | 5 | Contraintes - Inclinaison: 0.00999865; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1067781 | 145.318 | 2854.72 | 2852.64 | 2896.88 | 2894.8 | 2875.8 | 2873.72 | 2875.8 | 2873.72 | 2858.28 | 2856.2 | 2893.32 | 2891.24 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2856.2 | EU 17 | 0.014609 | 3.Condensats |  |  |  | 0.00130435 | 5 | Contraintes - Inclinaison: 0.0143073; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1067828 | 3946.48 | 2852.2 | 2812.74 | 2894.36 | 2854.9 | 2873.28 | 2833.82 | 2873.28 | 2833.82 | 2855.76 | 2816.29 | 2890.81 | 2851.34 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2816.29 | EU 17 | 0.396743 | 3.Condensats |  |  |  | 0.00130435 | 4 | Contraintes - Inclinaison: 0.01; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1067844 | 78.4618 | 2854 | 2853.22 | 2896.17 | 2895.38 | 2875.09 | 2874.3 | 2875.09 | 2874.3 | 2857.56 | 2856.78 | 2892.61 | 2891.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EU | Sanitaire | 32 | 2856.78 | EU 17 | 0.00788784 | 3.Condensats |  |  |  | 0.00130435 | 3 | Contraintes - Inclinaison: 0.01; Données d'identification - AI_Métré canalisation: EAU GLACEE; Génie climatique - Débit - Débit par appareil: 0
1067957 | 115 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 3 | 0.00903208 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1067989 | 60 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 4 | 0.00471239 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1156492 | 124.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2762 | 2886.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2886.3 | 2762 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2762 | EGA 1 | 0.0124959 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 1
1156528 | 124.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2762 | 2886.3 | 2886.3 | 2762 | 2886.3 | 2762 | 2886.3 | 2762 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2762 | EGA 1 | 0.0124959 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 1
1195132 | 199.472 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.0200531 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
1195152 | 3000.52 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.301645 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
1199947 | 54.5214 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.00548109 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 5
1203614 | 6032.48 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 3 | 0.47379 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1203779 | 5779.94 | 2117.12 | 2117.12 | 2150.52 | 2150.52 | 2133.82 | 2133.82 | 2133.82 | 2133.82 | 2120.49 | 2120.49 | 2147.14 | 2147.14 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -779.505 | FR 3 | 0.453955 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1203781 | 5698.03 | 2117.12 | 2117.12 | 2150.52 | 2150.52 | 2133.82 | 2133.82 | 2133.82 | 2133.82 | 2120.49 | 2120.49 | 2147.14 | 2147.14 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -779.505 | FR 4 | 0.447522 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1203783 | 5619.75 | 2117.12 | 2117.12 | 2150.52 | 2150.52 | 2133.82 | 2133.82 | 2133.82 | 2133.82 | 2120.49 | 2120.49 | 2147.14 | 2147.14 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -779.505 | FR 4 | 0.441374 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1203785 | 5537.47 | 2117.12 | 2117.12 | 2150.52 | 2150.52 | 2133.82 | 2133.82 | 2133.82 | 2133.82 | 2120.49 | 2120.49 | 2147.14 | 2147.14 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -779.505 | FR 3 | 0.434912 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1203826 | 424.187 | 2117.12 | 2117.12 | 2150.52 | 2150.52 | 2133.82 | 2133.82 | 2133.82 | 2133.82 | 2120.49 | 2120.49 | 2147.14 | 2147.14 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -779.505 | FR 3 | 0.0333155 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1203828 | 341.167 | 2117.12 | 2117.12 | 2150.52 | 2150.52 | 2133.82 | 2133.82 | 2133.82 | 2133.82 | 2120.49 | 2120.49 | 2147.14 | 2147.14 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -779.505 | FR 4 | 0.0267952 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1203830 | 263.399 | 2117.12 | 2117.12 | 2150.52 | 2150.52 | 2133.82 | 2133.82 | 2133.82 | 2133.82 | 2120.49 | 2120.49 | 2147.14 | 2147.14 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -779.505 | FR 4 | 0.0206873 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1203832 | 180.581 | 2117.12 | 2117.12 | 2150.52 | 2150.52 | 2133.82 | 2133.82 | 2133.82 | 2133.82 | 2120.49 | 2120.49 | 2147.14 | 2147.14 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -779.505 | FR 3 | 0.0141828 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1 | Données d'identification - AI_Métré canalisation: SERVEUR
1203922 | 419.483 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | 2158.82 | 2578.3 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -741.183 | FR 3 | 0.0329462 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1203957 | 419.483 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | 2158.82 | 2578.3 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -741.183 | FR 4 | 0.0329462 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1203996 | 419.483 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | 2158.82 | 2578.3 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -741.183 | FR 4 | 0.0329462 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1204033 | 419.483 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | 2158.82 | 2578.3 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | 2578.3 | 2158.82 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -741.183 | FR 3 | 0.0329462 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218173 | 370 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 3 | 0.0290597 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218181 | 423.943 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 3 | 0.0332964 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218198 | 479.298 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 4 | 0.037644 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218208 | 508.073 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 4 | 0.0399039 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218259 | 1514.96 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 4 | 0.118985 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218265 | 626.511 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 4 | 0.049206 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218275 | 305.203 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 4 | 0.0239706 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218292 | 1701.8 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 3 | 0.133659 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218300 | 633.052 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 3 | 0.0497198 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218312 | 195 | 2700.39 | 2700.39 | 2733.79 | 2733.79 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2703.77 | 2703.77 | 2730.41 | 2730.41 | RDC | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | 2703.77 | FR 3 | 0.0153153 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218819 | 1481.09 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 3 | 0.116325 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218864 | 6072.62 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 4 | 0.476943 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218872 | 1637.12 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 4 | 0.128579 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218884 | 7.64599 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 4 | 0.000600514 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218911 | 6117.72 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 4 | 0.480485 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218921 | 1782.28 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 4 | 0.13998 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218930 | 68.9712 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 4 | 0.00541699 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218956 | 6153.51 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 3 | 0.483296 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218964 | 1931.45 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 3 | 0.151696 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1218973 | 122.381 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | R-1 | 33.401 | 26.6446 | 3.3782 | 25 mmø | FR | Alimentation hydraulique | 25 | -310.022 | FR 3 | 0.00961177 | 0.Liaison frigorifique | 0 | Laminaire | no | 0 | 1
1229332 | 14995.3 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 1.50749 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 8
1229344 | 9.83365 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.000988586 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 8
1229354 | 340.543 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.0342351 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 8
1229399 | 51.3206 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.00515931 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 6
1229407 | 1535.68 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.154383 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 7
1229428 | 7.07107 | 2869.45 | 2864.45 | 2899.27 | 2894.27 | 2879.36 | 2884.36 | 2884.36 | 2879.36 | 2871.97 | 2866.97 | 2896.75 | 2891.75 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2866.97 | EGA 1 | 0.000710861 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 8 | Contraintes - Inclinaison: 1
1229481 | 1361.23 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.136845 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 7
1229552 | 14926.7 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 1.50059 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 8
1229560 | 6.54255 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.000657729 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 8
1229572 | 312.401 | 2897.22 | 2897.22 | 2939.38 | 2939.38 | 2918.3 | 2918.3 | 2918.3 | 2918.3 | 2900.77 | 2900.77 | 2935.83 | 2935.83 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2900.77 | EGA 1 | 0.031406 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 8
1229609 | 33.2004 | 2835.65 | 2835.65 | 2877.81 | 2877.81 | 2856.73 | 2856.73 | 2856.73 | 2856.73 | 2839.2 | 2839.2 | 2874.26 | 2874.26 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2839.2 | EGA 1 | 0.00333767 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 8
1229610 | 23.0711 | 2880.76 | 2864.45 | 2910.58 | 2894.27 | 2879.36 | 2895.67 | 2895.67 | 2879.36 | 2883.28 | 2866.97 | 2908.06 | 2891.75 | RDC | 42.164 | 35.052 | 3.556 | 32 mmø | EGA | Alimentation hydraulique | 32 | 2866.97 | EGA 1 | 0.00231936 | 0.Eau Glacée Aller | 0 | Laminaire | no | 0 | 8 | Contraintes - Inclinaison: 1

# IfcFlowSegment: Canalisation:Cuivre - Té (19)
In: RDC
Type - Autre - Catégorie: Canalisation; Nom de la famille: Canalisation
Type - Données d'identification - Sous-projet: Canalisation; Nom du type: Cuivre - Té
Pset_DistributionFlowElementCommon - Reference: Cuivre - Té; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Autre - Famille: Canalisation; Famille et type: Canalisation: Cuivre - Té; ID du type: 805380; Type: Cuivre - Té
Contraintes - Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: RDC
Cotes - Diamètre extérieur: 19.05 mm; Diamètre intérieur: 16.21 mm; Epaisseur de paroi: 1.42 mm; Taille: 20 mmø
Données d'identification - Sous-projet: 03_PLB
Génie climatique - Abréviation du système: EC; Classification du système: Eau chaude sanitaire; Diamètre: 20 mm; Matériau: Cuivre; Nomenclature/type: A; Rugosité: 0.00254 mm; Segment de canalisation: Cuivre - A; Type de connexion: Générique; Type de système: 2.Eau Chaude Sanitaire
Génie climatique - Débit - Etat du flux: Laminaire; Facteur de frottement: 0; Frottement: 0; Nombre de Reynolds: 0; Tronçon: 1; Débit: 0 m3/s; Débit par appareil: 0; Débit supplémentaire: 0 m3/s; Perte de pression: 0 Pa; Pression dynamique: 0 Pa; Rugosité relative: 0.000156693; Vitesse: 0 m/s
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 20 mmø
Name (Canalisation:Cuivre - Té:...) | Length (mm) = Longueur (mm) | Arase inférieure à son extrémité amont (mm) = Arase inférieure avec isolant à son extrémité amont (mm) | Arase inférieure à son extrémité aval (mm) = Arase inférieure avec isolant à son extrémité aval (mm) | Arase supérieure à son extrémité amont (mm) = Arase supérieure avec isolant à son extrémité amont (mm) | Arase supérieure à son extrémité aval (mm) = Arase supérieure avec isolant à son extrémité aval (mm) | Élévation centrale de départ (mm) = Elévation du milieu (mm) | Élévation centrale de fin (mm) | Elévation de l'axe à son extrémité amont (mm) | Elévation de l'axe à son extrémité aval (mm) | Elévation du fond (fil d'eau) à son extrémité amont (mm) | Elévation du fond (fil d'eau) à son extrémité aval (mm) = Elévation du fond (fil d'eau) (mm) | Elévation du point haut intérieur du tube à son extrémité amont (mm) | Elévation du point haut intérieur du tube à son extrémité aval (mm) | Nom du système = Group | Surface (m2)
936789 | 46.1091 | 1200 | 1153.89 | 1200 | 1153.89 | 1200 | 1153.89 | 1200 | 1153.89 | 1200 | 1153.89 | 1200 | 1153.89 | EC 1 | 0.00289712
936923 | 64.593 | 1125.45 | 1125.45 | 1144.5 | 1144.5 | 1134.98 | 1134.98 | 1134.98 | 1134.98 | 1126.87 | 1126.87 | 1143.08 | 1143.08 | EC 1 | 0.0040585
936935 | 1579.29 | 2733.18 | 1153.89 | 2733.18 | 1153.89 | 1153.89 | 2733.18 | 2733.18 | 1153.89 | 2733.18 | 1153.89 | 2733.18 | 1153.89 | EC 1 | 0.0992295
937003 | 1279.49 | 2742.56 | 2742.56 | 2761.61 | 2761.61 | 2752.09 | 2752.09 | 2752.09 | 2752.09 | 2743.98 | 2743.98 | 2760.19 | 2760.19 | EC 1 | 0.0803925
937011 | 513.984 | 2742.56 | 2742.56 | 2761.61 | 2761.61 | 2752.09 | 2752.09 | 2752.09 | 2752.09 | 2743.98 | 2743.98 | 2760.19 | 2760.19 | EC 1 | 0.0322946
937021 | 61.2154 | 2742.56 | 2742.56 | 2761.61 | 2761.61 | 2752.09 | 2752.09 | 2752.09 | 2752.09 | 2743.98 | 2743.98 | 2760.19 | 2760.19 | EC 1 | 0.00384628
937453 | 1132.55 | 2374.55 | 1242 | 2374.55 | 1242 | 2374.55 | 1242 | 2374.55 | 1242 | 2374.55 | 1242 | 2374.55 | 1242 | EC 1 | 0.07116
937596 | 46.1091 | 361.718 | 315.609 | 361.718 | 315.609 | 361.718 | 315.609 | 361.718 | 315.609 | 361.718 | 315.609 | 361.718 | 315.609 | EC 3 | 0.00289712
937602 | 693.968 | 287.172 | 287.172 | 306.222 | 306.222 | 296.697 | 296.697 | 296.697 | 296.697 | 288.592 | 288.592 | 304.802 | 304.802 | EC 3 | 0.0436033
937898 | 561.695 | 877.303 | 315.609 | 877.303 | 315.609 | 315.609 | 877.303 | 877.303 | 315.609 | 877.303 | 315.609 | 877.303 | 315.609 | EC 3 | 0.0352923
938270 | 46.1091 | 1200 | 1153.89 | 1200 | 1153.89 | 1200 | 1153.89 | 1200 | 1153.89 | 1200 | 1153.89 | 1200 | 1153.89 | EC 2 | 0.00289712
938282 | 64.5926 | 1125.45 | 1125.45 | 1144.5 | 1144.5 | 1134.98 | 1134.98 | 1134.98 | 1134.98 | 1126.87 | 1126.87 | 1143.08 | 1143.08 | EC 2 | 0.00405847
938286 | 1579.29 | 2733.18 | 1153.89 | 2733.18 | 1153.89 | 1153.89 | 2733.18 | 2733.18 | 1153.89 | 2733.18 | 1153.89 | 2733.18 | 1153.89 | EC 2 | 0.0992295
938292 | 1073.78 | 2742.56 | 2742.56 | 2761.61 | 2761.61 | 2752.09 | 2752.09 | 2752.09 | 2752.09 | 2743.98 | 2743.98 | 2760.19 | 2760.19 | EC 2 | 0.0674673
938294 | 254.575 | 2742.56 | 2742.56 | 2761.61 | 2761.61 | 2752.09 | 2752.09 | 2752.09 | 2752.09 | 2743.98 | 2743.98 | 2760.19 | 2760.19 | EC 2 | 0.0159954
938298 | 55.6732 | 2742.56 | 2742.56 | 2761.61 | 2761.61 | 2752.09 | 2752.09 | 2752.09 | 2752.09 | 2743.98 | 2743.98 | 2760.19 | 2760.19 | EC 2 | 0.00349805
938328 | 1516.09 | 2733.18 | 1217.09 | 2733.18 | 1217.09 | 2733.18 | 1217.09 | 2733.18 | 1217.09 | 2733.18 | 1217.09 | 2733.18 | 1217.09 | EC 2 | 0.0952586
1237825 | 320.808 | 2733.18 | 2412.37 | 2733.18 | 2412.37 | 2733.18 | 2412.37 | 2733.18 | 2412.37 | 2733.18 | 2412.37 | 2733.18 | 2412.37 | EC 1 | 0.020157
1237851 | 69.7534 | 2383.93 | 2383.93 | 2402.98 | 2402.98 | 2393.46 | 2393.46 | 2393.46 | 2393.46 | 2385.35 | 2385.35 | 2401.56 | 2401.56 | EC 1 | 0.00438274

# IfcFlowSegment: Canalisation:PVC (114)
In: RDC
Type - Autre - Catégorie: Canalisation; Nom de la famille: Canalisation
Type - Données d'identification - Sous-projet: Canalisation; Commentaires du type: PVC; Nom du type: PVC
Pset_DistributionFlowElementCommon - Reference: PVC; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Autre - Famille: Canalisation; Famille et type: Canalisation: PVC; ID du type: 804521; Type: PVC
Contraintes - Justification horizontale: Centre; Justification verticale: Milieu
Génie climatique - Classification du système: Sanitaire; Matériau: PVC-U; Nomenclature/type: NF EN 1329-1; Rugosité: 0.00254 mm; Segment de canalisation: PVC-U - NF EN 1329-1; Type de connexion: Générique
Génie climatique - Débit - Débit par appareil: 0
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Name (Canalisation:PVC:...) | Length (mm) = Longueur (mm) | Niveau de référence | Arase inférieure à son extrémité amont (mm) = Arase inférieure avec isolant à son extrémité amont (mm) | Arase inférieure à son extrémité aval (mm) = Arase inférieure avec isolant à son extrémité aval (mm) | Arase supérieure à son extrémité amont (mm) = Arase supérieure avec isolant à son extrémité amont (mm) | Arase supérieure à son extrémité aval (mm) = Arase supérieure avec isolant à son extrémité aval (mm) | Élévation centrale de départ (mm) = Elévation du milieu (mm) | Élévation centrale de fin (mm) | Elévation de l'axe à son extrémité amont (mm) | Elévation de l'axe à son extrémité aval (mm) | Elévation du fond (fil d'eau) à son extrémité amont (mm) | Elévation du fond (fil d'eau) à son extrémité aval (mm) | Elévation du point haut intérieur du tube à son extrémité amont (mm) | Elévation du point haut intérieur du tube à son extrémité aval (mm) | Inclinaison | Diamètre extérieur (mm) = Diamètre (mm) | Diamètre intérieur (mm) | Epaisseur de paroi (mm) | Taille = Taille globale | Sous-projet | Abréviation du système | Elévation du fond (fil d'eau) (mm) | Nom du système | Surface (m2) | Type de système | Tronçon | Rugosité relative | Group
942939 | 568.918 | RDC | 203.847 | -365.071 | 203.87 | -365.048 | -365.06 | 203.859 | 203.859 | -365.06 | 203.848 | -365.07 | 203.869 | -365.049 | 4359.61 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -365.07 | EV 1 | 0.178731 | 3.Eaux Vannes | 1 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
942950 | 583.831 | RDC | 202.779 | -380.931 | 204.81 | -378.9 | -379.915 | 203.795 | 203.795 | -379.915 | 202.84 | -380.87 | 204.75 | -378.96 | 49.2134 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -380.87 | EV 1 | 0.183416 | 3.Eaux Vannes | 9 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
942963 | 599.177 | RDC | 203.851 | -395.326 | 203.866 | -395.31 | -395.318 | 203.859 | 203.859 | -395.318 | 203.851 | -395.325 | 203.866 | -395.311 | 6459.88 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -395.325 | EV 1 | 0.188237 | 3.Eaux Vannes | 11 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943074 | 553.395 | RDC | 203.842 | -349.553 | 203.875 | -349.52 | -349.536 | 203.859 | 203.859 | -349.536 | 203.843 | -349.552 | 203.874 | -349.521 | 3034.23 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -349.552 | EV 1 | 0.173854 | 3.Eaux Vannes | 5 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943362 | 125.192 | R-1 | 2369.58 | 2367.7 | 2469.57 | 2467.69 | 2419.58 | 2417.7 | 2419.58 | 2417.7 | 2372.58 | 2370.7 | 2466.57 | 2464.69 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -529.296 | EV 1 | 0.0393303 | 3.Eaux Vannes | 6 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943366 | 4188.57 | R-1 | 2260.77 | 2197.95 | 2360.76 | 2297.94 | 2310.77 | 2247.95 | 2310.77 | 2247.95 | 2263.77 | 2200.95 | 2357.76 | 2294.94 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -699.05 | EV 1 | 1.31588 | 3.Eaux Vannes | 12 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943368 | 8148.83 | R-1 | 2195.64 | 2073.42 | 2295.63 | 2173.41 | 2123.42 | 2245.64 | 2245.64 | 2123.42 | 2198.64 | 2076.42 | 2292.63 | 2170.41 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -823.578 | EV 1 | 2.56003 | 3.Eaux Vannes | 12 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943385 | 4542.44 | R-1 | 2071.11 | 2002.98 | 2171.1 | 2102.97 | 2052.98 | 2121.11 | 2121.11 | 2052.98 | 2074.11 | 2005.98 | 2168.1 | 2099.97 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -894.017 | EV 1 | 1.42705 | 3.Eaux Vannes | 12 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943387 | 548.273 | RDC | 203.859 | -344.414 | 203.859 | -344.414 | 203.859 | -344.414 | 203.859 | -344.414 | 203.859 | -344.414 | 203.859 | -344.414 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -344.414 | EV 1 | 0.172245 | 3.Eaux Vannes | 6 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
943522 | 1916.97 | R-1 | 1916.97 | 0 | 1916.97 | 0 | 1916.97 | 0 | 1916.97 | 0 | 1916.97 | 0 | 1916.97 | 0 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -2900 | EV 1 | 0.602233 | 3.Eaux Vannes | 12 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
944036 | 643.009 | RDC | 203.858 | -439.151 | 203.86 | -439.149 | 203.859 | -439.15 | 203.859 | -439.15 | 203.858 | -439.151 | 203.859 | -439.149 | 17331 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -439.151 | EU 2 | 0.0646423 | 3.Eaux Usées | 5 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945123 | 640.576 | RDC | 203.854 | -436.722 | 203.863 | -436.713 | -436.717 | 203.859 | 203.859 | -436.717 | 203.855 | -436.721 | 203.862 | -436.714 | 3674.76 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -436.721 | EU 2 | 0.0643977 | 3.Eaux Usées | 23 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945443 | 217.092 | R-1 | 2397.38 | 2397 | 2429.38 | 2429 | 2413 | 2413.38 | 2413.38 | 2413 | 2400.38 | 2400 | 2426.38 | 2426 | 0.00176643 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -500.001 | EU 2 | 0.0218245 | 3.Eaux Usées | 5 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945729 | 4502.97 | R-1 | 2052.88 | 1985.35 | 2152.87 | 2085.33 | 2035.34 | 2102.88 | 2102.88 | 2035.34 | 2055.88 | 1988.35 | 2149.87 | 2082.33 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -911.654 | EU 2 | 1.41465 | 3.Eaux Usées | 32 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945733 | 3474.68 | R-1 | 2237.11 | 2184.99 | 2337.09 | 2284.98 | 2234.99 | 2287.1 | 2287.1 | 2234.99 | 2240.1 | 2187.99 | 2334.09 | 2281.98 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -712.01 | EU 2 | 1.0916 | 3.Eaux Usées | 18 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945735 | 960.282 | R-1 | 2357.18 | 2342.77 | 2457.17 | 2442.76 | 2392.77 | 2407.17 | 2407.17 | 2392.77 | 2360.18 | 2345.77 | 2454.17 | 2439.76 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -554.226 | EU 2 | 0.301681 | 3.Eaux Usées | 12 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945737 | 2054.37 | R-1 | 2424.69 | 2393.88 | 2456.69 | 2425.88 | 2409.88 | 2440.69 | 2440.69 | 2409.88 | 2427.69 | 2396.88 | 2453.69 | 2422.88 | 0.015 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -503.117 | EU 2 | 0.206528 | 3.Eaux Usées | 10 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945739 | 3374.15 | R-1 | 2476.74 | 2426.13 | 2508.74 | 2458.13 | 2492.74 | 2442.13 | 2492.74 | 2442.13 | 2479.74 | 2429.13 | 2505.74 | 2455.13 | 0.015 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -470.866 | EU 2 | 0.339207 | 3.Eaux Usées | 10 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945764 | 1899.33 | R-1 | 1899.33 | 0 | 1899.33 | 0 | 0 | 1899.33 | 1899.33 | 0 | 1899.33 | 0 | 1899.33 | 0 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -2900 | EU 2 | 0.596692 | 3.Eaux Usées | 32 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945766 | 562.4 | RDC | 203.859 | -358.541 | 203.859 | -358.541 | 203.859 | -358.541 | 203.859 | -358.541 | 203.859 | -358.541 | 203.859 | -358.541 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -358.541 | EU 2 | 0.0565386 | 3.Eaux Usées | 10 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
945987 | 91.8371 | R-1 | 2366.1 | 2364.73 | 2466.09 | 2464.71 | 2414.72 | 2416.1 | 2416.1 | 2414.72 | 2369.1 | 2367.73 | 2463.09 | 2461.71 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -532.275 | EU 2 | 0.0288515 | 3.Eaux Usées | 15 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946227 | 190.03 | R-1 | 2362.38 | 2359.53 | 2462.37 | 2459.51 | 2409.52 | 2412.37 | 2412.37 | 2409.52 | 2365.38 | 2362.53 | 2459.37 | 2456.52 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -537.474 | EU 2 | 0.0596996 | 3.Eaux Usées | 14 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946268 | 640.483 | RDC | 200.81 | -439.673 | 200.811 | -439.672 | 200.811 | -439.672 | 200.811 | -439.672 | 200.81 | -439.673 | 200.811 | -439.672 | 20050.1 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -439.673 | EU 2 | 0.0643884 | 3.Eaux Usées | 6 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946570 | 2339.85 | R-1 | 2340.43 | 2305.33 | 2440.41 | 2405.32 | 2355.33 | 2390.42 | 2390.42 | 2355.33 | 2343.42 | 2308.33 | 2437.41 | 2402.32 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -591.669 | EU 2 | 0.735086 | 3.Eaux Usées | 13 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946604 | 1958 | R-1 | 2470.74 | 2441.37 | 2502.74 | 2473.37 | 2486.74 | 2457.37 | 2486.74 | 2457.37 | 2473.74 | 2444.37 | 2499.74 | 2470.37 | 0.015 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -455.626 | EU 2 | 0.19684 | 3.Eaux Usées | 17 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946606 | 565.352 | RDC | 200.81 | -364.542 | 200.812 | -364.54 | 200.811 | -364.541 | 200.811 | -364.541 | 200.81 | -364.542 | 200.811 | -364.541 | 16121.4 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -364.542 | EU 2 | 0.0568354 | 3.Eaux Usées | 17 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946783 | 57.6251 | R-1 | 2424.18 | 2392.15 | 2450.78 | 2418.75 | 2405.45 | 2437.48 | 2437.48 | 2405.45 | 2426.67 | 2394.64 | 2448.29 | 2416.26 | 0.668625 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -505.358 | EU 2 | 0.00579311 | 3.Eaux Usées | 17 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946804 | 1422.87 | R-1 | 2302.97 | 2281.63 | 2402.96 | 2381.62 | 2331.63 | 2352.97 | 2352.97 | 2331.63 | 2305.97 | 2284.63 | 2399.96 | 2378.62 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -615.369 | EU 2 | 0.447009 | 3.Eaux Usées | 16 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946838 | 1662.83 | R-1 | 2473.87 | 2448.93 | 2505.86 | 2480.92 | 2489.86 | 2464.92 | 2489.86 | 2464.92 | 2476.87 | 2451.93 | 2502.86 | 2477.92 | 0.015 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -448.075 | EU 2 | 0.167166 | 3.Eaux Usées | 20 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
946840 | 562.227 | RDC | 200.806 | -361.421 | 200.815 | -361.412 | 200.811 | -361.417 | 200.811 | -361.417 | 200.807 | -361.42 | 200.814 | -361.413 | 3693.22 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -361.42 | EU 2 | 0.0565212 | 3.Eaux Usées | 20 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
947098 | 21.2864 | R-1 | 2429.06 | 2414.01 | 2451.69 | 2436.64 | 2440.37 | 2425.32 | 2440.37 | 2425.32 | 2431.18 | 2416.13 | 2449.57 | 2434.52 | 0.999845 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -483.869 | EU 2 | 0.00213995 | 3.Eaux Usées | 20 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
947465 | 2544.3 | R-1 | 2279.28 | 2241.12 | 2379.27 | 2341.11 | 2291.12 | 2329.28 | 2329.28 | 2291.12 | 2282.28 | 2244.12 | 2376.27 | 2338.11 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -655.876 | EU 2 | 0.799316 | 3.Eaux Usées | 18 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
947580 | 56.7787 | R-1 | 2182.62 | 2181.77 | 2282.61 | 2281.76 | 2231.77 | 2232.62 | 2232.62 | 2231.77 | 2185.62 | 2184.77 | 2279.61 | 2278.76 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -715.228 | EU 2 | 0.0178376 | 3.Eaux Usées | 35 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
947620 | 295.23 | R-1 | 2468.01 | 2463.58 | 2500 | 2495.57 | 2479.58 | 2484 | 2484 | 2479.58 | 2471.01 | 2466.58 | 2497 | 2492.57 | 0.015 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -433.422 | EU 2 | 0.0296798 | 3.Eaux Usées | 21 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
947622 | 103.195 | R-1 | 2430.62 | 2327.44 | 2431.1 | 2327.92 | 2327.68 | 2430.86 | 2430.86 | 2327.68 | 2430.67 | 2327.48 | 2431.06 | 2327.88 | 66.1078 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -572.518 | EU 2 | 0.0103743 | 3.Eaux Usées | 21 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
947624 | 568.112 | RDC | 200.832 | -367.28 | 200.84 | -367.272 | 200.836 | -367.276 | 200.836 | -367.276 | 200.833 | -367.279 | 200.84 | -367.273 | 4092.3 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -367.279 | EU 2 | 0.0571129 | 3.Eaux Usées | 21 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
947938 | 205.897 | R-1 | 2364.4 | 2361.32 | 2464.39 | 2461.31 | 2414.4 | 2411.31 | 2414.4 | 2411.31 | 2367.4 | 2364.32 | 2461.39 | 2458.31 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -535.684 | EV 1 | 0.0646846 | 3.Eaux Vannes | 6 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
947962 | 787.455 | R-1 | 2357.6 | 2345.79 | 2457.59 | 2445.78 | 2407.6 | 2395.79 | 2407.6 | 2395.79 | 2360.6 | 2348.79 | 2454.59 | 2442.78 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -551.208 | EV 1 | 0.247386 | 3.Eaux Vannes | 7 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
947990 | 742.954 | R-1 | 2342.08 | 2330.94 | 2442.07 | 2430.93 | 2392.07 | 2380.93 | 2392.07 | 2380.93 | 2345.08 | 2333.94 | 2439.07 | 2427.93 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -566.063 | EV 1 | 0.233406 | 3.Eaux Vannes | 8 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
948010 | 3135.68 | R-1 | 2311.82 | 2264.79 | 2411.81 | 2364.78 | 2361.82 | 2314.79 | 2361.82 | 2314.79 | 2314.82 | 2267.79 | 2408.81 | 2361.78 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -632.209 | EV 1 | 0.985102 | 3.Eaux Vannes | 12 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
948019 | 781.344 | R-1 | 2327.25 | 2315.53 | 2427.24 | 2415.52 | 2377.25 | 2365.53 | 2377.25 | 2365.53 | 2330.25 | 2318.53 | 2424.24 | 2412.52 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -581.466 | EV 1 | 0.245467 | 3.Eaux Vannes | 10 | 0.0000270213 | EV 1 | Données d'identification - AI_Phase: EXISTANT
948928 | 780.971 | R-1 | 2388.72 | 2377.12 | 2420.72 | 2409.11 | 2404.72 | 2393.12 | 2404.72 | 2393.12 | 2391.72 | 2380.12 | 2417.72 | 2406.11 | 0.0148596 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -519.883 | EU 2 | 0.0785118 | 3.Eaux Usées | 24 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
948937 | 368.22 | R-1 | 2395.62 | 2390.15 | 2427.61 | 2422.14 | 2411.61 | 2406.14 | 2411.61 | 2406.14 | 2398.62 | 2393.15 | 2424.61 | 2419.14 | 0.0148596 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -506.855 | EU 2 | 0.0370175 | 3.Eaux Usées | 6 | 0.0000976923 | EU 2 | Données d'identification - AI_Phase: EXISTANT
1065233 | 3100 | R-1 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 |  | 200 | 192.2 | 3.9 | 200 mmø | 03_PLB | EP | -200 | EP 2 | 1.94779 | 3.Eaux Pluviales | 1 | 0.0000132154 | EP 2
1065320 | 3100 | R-1 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 |  | 200 | 192.2 | 3.9 | 200 mmø | 03_PLB | EP | -200 | EP 1 | 1.94779 | 3.Eaux Pluviales | 1 | 0.0000132154 | EP 1
1065335 | 3100 | R-1 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 |  | 200 | 192.2 | 3.9 | 200 mmø | 03_PLB | EP | -200 | EP 3 | 1.94779 | 3.Eaux Pluviales | 1 | 0.0000132154 | EP 3
1065346 | 3100 | R-1 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 |  | 200 | 192.2 | 3.9 | 200 mmø | 03_PLB | EP | -200 | EP 4 | 1.94779 | 3.Eaux Pluviales | 1 | 0.0000132154 | EP 4
1065365 | 3100 | R-1 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 |  | 200 | 192.2 | 3.9 | 200 mmø | 03_PLB | EP | -200 | EP 5 | 1.94779 | 3.Eaux Pluviales | 1 | 0.0000132154 | EP 5
1158673 | 3100 | R-1 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 |  | 200 | 192.2 | 3.9 | 200 mmø | 03_PLB | EP | -200 | EP 7 | 1.94779 | 3.Eaux Pluviales | 1 | 0.0000132154 | EP 7
1158747 | 3100 | R-1 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 | 5800 | 2700 |  | 200 | 192.2 | 3.9 | 200 mmø | 03_PLB | EP | -200 | EP 6 | 1.94779 | 3.Eaux Pluviales | 1 | 0.0000132154 | EP 6
1207384 | 834.62 | RDC | 545 | -289.62 | 545 | -289.62 | 545 | -289.62 | 545 | -289.62 | 545 | -289.62 | 545 | -289.62 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -289.62 | EU 10 | 0.0839052 | 3.Eaux Usées | 7 | 0.0000976923 | EU 10
1211294 | 192.051 | R-1 | 2179.46 | 2176.58 | 2279.45 | 2276.57 | 2226.58 | 2229.46 | 2229.46 | 2226.58 | 2182.46 | 2179.58 | 2276.45 | 2273.57 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -720.418 | EU 2 | 0.0603345 | 3.Eaux Usées | 35 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
1212555 | 336 | RDC | 77.6378 | -258.362 | 77.6378 | -258.362 | 77.6378 | -258.362 | 77.6378 | -258.362 | 77.6378 | -258.362 | 77.6378 | -258.362 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -258.362 | EV 4 | 0.105558 | 3.Eaux Vannes | 10 | 0.0000270213 | EV 4
1212761 | 60 | RDC | 382.113 | 322.113 | 382.113 | 322.113 | 322.113 | 382.113 | 382.113 | 322.113 | 382.113 | 322.113 | 382.113 | 322.113 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | 322.113 | EV 4 | 0.0188496 | 3.Eaux Vannes | 11 | 0.0000270213 | EV 4
1212889 | 82.5 | RDC | 170.513 | 170.513 | 270.513 | 270.513 | 220.513 | 220.513 | 220.513 | 220.513 | 173.513 | 173.513 | 267.513 | 267.513 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | 173.513 | EV 4 | 0.0259181 | 3.Eaux Vannes | 13 | 0.0000270213 | EV 4
1212917 | 77.5 | RDC | 170.513 | 170.513 | 270.513 | 270.513 | 220.513 | 220.513 | 220.513 | 220.513 | 173.513 | 173.513 | 267.513 | 267.513 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | 173.513 | EV 4 | 0.0243473 | 3.Eaux Vannes | 12 | 0.0000270213 | EV 4
1213433 | 178.506 | RDC | -176.462 | -354.968 | -176.462 | -354.968 | -176.462 | -354.968 | -176.462 | -354.968 | -176.462 | -354.968 | -176.462 | -354.968 |  | 50 | 44 | 3 | 50 mmø | 03_PLB | EU | -354.968 | EU 9 | 0.0280396 | 3.Eaux Usées | 1 | 0.0000577273 | EU 9
1213678 | 112.037 | RDC | -176.467 | -288.504 | -176.458 | -288.495 | -176.462 | -288.499 | -176.462 | -288.499 | -176.466 | -288.503 | -176.458 | -288.495 |  | 50 | 44 | 3 | 50 mmø | 03_PLB | EU | -288.503 | EU 8 | 0.0175988 | 3.Eaux Usées | 1 | 0.0000577273 | EU 8
1214626 | 1268.7 | RDC | 905 | -363.699 | 905 | -363.699 | -363.699 | 905 | 905 | -363.699 | 905 | -363.699 | 905 | -363.699 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -363.699 | EU 7 | 0.127544 | 3.Eaux Usées | 7 | 0.0000976923 | EU 7
1216916 | 2905.74 | RDC | 2589.05 | -316.687 | 2589.05 | -316.687 | 2589.05 | -316.687 | 2589.05 | -316.687 | 2589.05 | -316.687 | 2589.05 | -316.687 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -316.687 | EU 3 | 0.292117 | 3.Eaux Usées | 8 | 0.0000976923 | EU 3
1218446 | 2667.8 | RDC | 2354.25 | -313.549 | 2354.25 | -313.549 | 2354.25 | -313.549 | 2354.25 | -313.549 | 2354.25 | -313.549 | 2354.25 | -313.549 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -313.549 | EU 5 | 0.268197 | 3.Eaux Usées | 10 | 0.0000976923 | EU 5
1218448 | 2704.88 | RDC | 2427.54 | 2386.98 | 2459.54 | 2418.97 | 2443.54 | 2402.97 | 2443.54 | 2402.97 | 2430.54 | 2389.98 | 2456.54 | 2415.97 | 0.015 | 32 | 26 | 3 | 32 mmø | 01_CVC | EU | 2389.98 | EU 18 | 0.271924 | 3.Condensats | 6 | 0.0000976923 | EU 18
1218508 | 3572.41 | RDC | 2687.7 | 2634.12 | 2719.7 | 2666.12 | 2650.12 | 2703.7 | 2703.7 | 2650.12 | 2690.7 | 2637.12 | 2716.7 | 2663.12 | 0.015 | 32 | 26 | 3 | 32 mmø | 01_CVC | EU | 2637.12 | EU 4 | 0.359138 | 3.Condensats | 4 | 0.0000976923 | EU 4
1218510 | 123.321 | RDC | 2875.74 | 2752.42 | 2875.74 | 2752.42 | 2875.74 | 2752.42 | 2875.74 | 2752.42 | 2875.74 | 2752.42 | 2875.74 | 2752.42 |  | 32 | 26 | 3 | 32 mmø | 01_CVC | EU | 2752.42 | EU 4 | 0.0123976 | 3.Condensats | 4 | 0.0000976923 | EU 4
1218515 | 727.2 | RDC | 2632.68 | 2621.78 | 2664.68 | 2653.77 | 2637.77 | 2648.68 | 2648.68 | 2637.77 | 2635.68 | 2624.78 | 2661.68 | 2650.77 | 0.015 | 32 | 26 | 3 | 32 mmø | 01_CVC | EU | 2624.78 | EU 4 | 0.0731061 | 3.Condensats | 4 | 0.0000976923 | EU 4
1218517 | 1460.5 | RDC | 2930.37 | 2908.46 | 2962.36 | 2940.46 | 2946.37 | 2924.46 | 2946.37 | 2924.46 | 2933.37 | 2911.46 | 2959.37 | 2937.46 | 0.015 | 32 | 26 | 3 | 32 mmø | 01_CVC | EU | 2911.46 | EU 4 | 0.146825 | 3.Condensats | 4 | 0.0000976923 | EU 4
1219443 | 15.8325 | R-1 | 2417.3 | 2417.3 | 2517.3 | 2517.3 | 2467.3 | 2467.3 | 2467.3 | 2467.3 | 2420.3 | 2420.3 | 2514.3 | 2514.3 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -479.696 | U 2 | 0.00497393 | 3.Unitaire | 16 | 0.0000270213 | U 2
1219632 | 13.7693 | R-1 | 2374.72 | 2366.83 | 2456.64 | 2448.74 | 2415.68 | 2407.78 | 2415.68 | 2407.78 | 2377.18 | 2369.28 | 2454.18 | 2446.28 | 0.700206 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -530.716 | U 2 | 0.00432576 | 3.Unitaire | 16 | 0.0000270213 | U 2
1220114 | 248.03 | R-1 | 2304.73 | 2302.25 | 2404.73 | 2402.25 | 2352.25 | 2354.73 | 2354.73 | 2352.25 | 2307.73 | 2305.25 | 2401.73 | 2399.25 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -594.747 | U 2 | 0.0779208 | 3.Unitaire | 16 | 0.0000270213 | U 2
1220118 | 101.801 | R-1 | 2306.07 | 2306.07 | 2406.07 | 2406.07 | 2356.07 | 2356.07 | 2356.07 | 2356.07 | 2309.07 | 2309.07 | 2403.07 | 2403.07 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -590.93 | U 2 | 0.0319818 | 3.Unitaire | 16 | 0.0000270213 | U 2
1220200 | 491.701 | RDC | -384.298 | -384.474 | -334.298 | -334.474 | -359.474 | -359.298 | -359.298 | -359.474 | -381.298 | -381.474 | -337.298 | -337.474 | 0.000358492 | 50 | 44 | 3 | 50 mmø | 03_PLB | EU | -381.474 | EU 8 | 0.0772362 | 3.Eaux Usées | 1 | 0.0000577273 | EU 8
1220314 | 177.365 | R-1 | 2493.3 | 2491.53 | 2593.3 | 2591.52 | 2543.3 | 2541.53 | 2543.3 | 2541.53 | 2496.3 | 2494.53 | 2590.3 | 2588.52 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -405.471 | U 2 | 0.0557208 | 3.Unitaire | 6 | 0.0000270213 | U 2
1220371 | 1228.54 | RDC | 905 | -323.542 | 905 | -323.542 | 905 | -323.542 | 905 | -323.542 | 905 | -323.542 | 905 | -323.542 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -323.542 | EU 6 | 0.123506 | 3.Eaux Usées | 8 | 0.0000976923 | EU 6
1220382 | 450.731 | RDC | -386.615 | -387.432 | -354.615 | -355.432 | -371.432 | -370.615 | -370.615 | -371.432 | -383.615 | -384.432 | -357.615 | -358.432 | 0.00181145 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -384.432 | EU 6 | 0.0453124 | 3.Eaux Usées | 8 | 0.0000976923 | EU 6
1220558 | 947.504 | R-1 | 2489.77 | 2480.3 | 2589.77 | 2580.29 | 2539.77 | 2530.3 | 2539.77 | 2530.3 | 2492.77 | 2483.3 | 2586.77 | 2577.29 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -416.701 | U 2 | 0.297667 | 3.Unitaire | 4 | 0.0000270213 | U 2
1220621 | 1143.88 | RDC | -270.054 | -281.492 | -238.056 | -249.494 | -254.055 | -265.493 | -254.055 | -265.493 | -267.054 | -278.492 | -241.055 | -252.494 | 0.01 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -278.492 | EU 19 | 0.114995 | 3.Eaux Usées | 9 | 0.0000976923 | EU 19
1220623 | 343.272 | RDC | 777.346 | 434.074 | 777.346 | 434.074 | 434.074 | 777.346 | 777.346 | 434.074 | 777.346 | 434.074 | 777.346 | 434.074 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | 434.074 | EU 19 | 0.0345095 | 3.Eaux Usées | 10 | 0.0000976923 | EU 19
1220670 | 104.721 | RDC | -441.218 | -441.826 | -341.22 | -341.828 | -391.827 | -391.219 | -391.219 | -391.827 | -438.218 | -438.826 | -344.22 | -344.828 | 0.00580665 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -438.826 | EV 4 | 0.0328991 | 3.Eaux Vannes | 10 | 0.0000270213 | EV 4
1220778 | 1904.98 | R-1 | 2478.73 | 2459.68 | 2578.73 | 2559.68 | 2528.73 | 2509.68 | 2528.73 | 2509.68 | 2481.73 | 2462.68 | 2575.73 | 2556.68 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -437.316 | U 2 | 0.598466 | 3.Unitaire | 7 | 0.0000270213 | U 2
1221009 | 103.149 | RDC | -301.188 | -374.126 | -278.561 | -351.498 | -289.875 | -362.812 | -289.875 | -362.812 | -299.067 | -372.004 | -280.682 | -353.619 | 1 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -372.004 | EU 19 | 0.0103697 | 3.Eaux Usées | 9 | 0.0000976923 | EU 19
1221026 | 131.029 | RDC | -407.815 | -407.852 | -375.815 | -375.852 | -391.815 | -391.852 | -391.815 | -391.852 | -404.815 | -404.852 | -378.815 | -378.852 | 0.00028157 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -404.852 | EU 19 | 0.0131725 | 3.Eaux Usées | 9 | 0.0000976923 | EU 19
1221246 | 450.73 | RDC | -427.76 | -428.208 | -395.76 | -396.208 | -411.76 | -412.208 | -411.76 | -412.208 | -424.76 | -425.208 | -398.76 | -399.208 | 0.000994553 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -425.208 | EU 7 | 0.0453123 | 3.Eaux Usées | 7 | 0.0000976923 | EU 7
1221469 | 1880.03 | R-1 | 2457.17 | 2438.37 | 2557.17 | 2538.37 | 2507.17 | 2488.37 | 2507.17 | 2488.37 | 2460.17 | 2441.37 | 2554.17 | 2535.37 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -458.626 | U 2 | 0.590627 | 3.Unitaire | 10 | 0.0000270213 | U 2
1221517 | 491.704 | RDC | -451.233 | -452.686 | -401.234 | -402.686 | -426.233 | -427.686 | -426.233 | -427.686 | -448.233 | -449.686 | -404.234 | -405.686 | 0.0029547 | 50 | 44 | 3 | 50 mmø | 03_PLB | EU | -449.686 | EU 9 | 0.0772366 | 3.Eaux Usées | 1 | 0.0000577273 | EU 9
1221620 | 231.529 | R-1 | 2420.96 | 2418.65 | 2520.96 | 2518.64 | 2470.96 | 2468.64 | 2470.96 | 2468.64 | 2423.96 | 2421.65 | 2517.96 | 2515.64 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -478.354 | U 2 | 0.0727369 | 3.Unitaire | 16 | 0.0000270213 | U 2
1221634 | 747.566 | R-1 | 2430.19 | 2422.72 | 2530.19 | 2522.71 | 2480.19 | 2472.72 | 2480.19 | 2472.72 | 2433.19 | 2425.72 | 2527.19 | 2519.71 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -474.282 | U 2 | 0.234855 | 3.Unitaire | 14 | 0.0000270213 | U 2
1221845 | 36 | R-1 | 2435.6 | 2435.24 | 2535.59 | 2535.23 | 2485.6 | 2485.24 | 2485.6 | 2485.24 | 2438.6 | 2438.24 | 2532.59 | 2532.23 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -461.762 | U 1 | 0.0113097 | 3.Unitaire | 15 | 0.0000270213 | U 1
1221847 | 3505.5 | R-1 | 2307.81 | 2272.76 | 2407.81 | 2372.75 | 2357.81 | 2322.76 | 2357.81 | 2322.76 | 2310.81 | 2275.76 | 2404.81 | 2369.75 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -624.242 | U 1 | 1.10129 | 3.Unitaire | 15 | 0.0000270213 | U 1
1221940 | 120.771 | R-1 | 2311.7 | 2310.49 | 2411.69 | 2410.49 | 2361.7 | 2360.49 | 2361.7 | 2360.49 | 2314.7 | 2313.49 | 2408.69 | 2407.49 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -586.509 | U 1 | 0.0379413 | 3.Unitaire | 15 | 0.0000270213 | U 1
1222042 | 32.2448 | R-1 | 2391.76 | 2373.26 | 2473.67 | 2455.18 | 2432.71 | 2414.22 | 2432.71 | 2414.22 | 2394.21 | 2375.72 | 2471.21 | 2452.72 | 0.700208 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -524.282 | U 1 | 0.01013 | 3.Unitaire | 15 | 0.0000270213 | U 1
1222110 | 679.62 | RDC | -353.658 | -354.108 | -321.658 | -322.108 | -337.658 | -338.108 | -337.658 | -338.108 | -350.658 | -351.108 | -324.658 | -325.108 | 0.000661972 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -351.108 | EU 10 | 0.0683229 | 3.Eaux Usées | 7 | 0.0000976923 | EU 10
1222238 | 141.176 | R-1 | 2513.93 | 2512.52 | 2613.93 | 2612.52 | 2563.93 | 2562.52 | 2563.93 | 2562.52 | 2516.93 | 2515.52 | 2610.93 | 2609.52 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -384.48 | U 1 | 0.0443519 | 3.Unitaire | 11 | 0.0000270213 | U 1
1222266 | 502.567 | RDC | 277.631 | -224.936 | 277.635 | -224.932 | 277.633 | -224.934 | 277.633 | -224.934 | 277.631 | -224.935 | 277.635 | -224.932 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -224.935 | EV 2 | 0.157886 | 3.Eaux Vannes | 8 | 0.0000270213 | EV 2
1222274 | 181.948 | RDC | -408.595 | -408.674 | -308.595 | -308.674 | -358.674 | -358.595 | -358.595 | -358.674 | -405.595 | -405.674 | -311.595 | -311.674 | 0.000437922 | 100 | 94 | 3 | 100 mmø | 03_PLB | EV | -405.674 | EV 2 | 0.0571605 | 3.Eaux Vannes | 8 | 0.0000270213 | EV 2
1222345 | 1819.24 | R-1 | 2510.95 | 2492.76 | 2610.95 | 2592.76 | 2560.95 | 2542.76 | 2560.95 | 2542.76 | 2513.95 | 2495.76 | 2607.95 | 2589.76 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -404.238 | U 1 | 0.571532 | 3.Unitaire | 8 | 0.0000270213 | U 1
1222375 | 663.689 | RDC | -377.531 | -377.547 | -345.531 | -345.547 | -361.547 | -361.531 | -361.531 | -361.547 | -374.531 | -374.547 | -348.531 | -348.547 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -374.547 | EU 5 | 0.0667213 | 3.Eaux Usées | 10 | 0.0000976923 | EU 5
1222510 | 4933.04 | R-1 | 2487.61 | 2438.28 | 2587.6 | 2538.27 | 2537.6 | 2488.28 | 2537.6 | 2488.28 | 2490.61 | 2441.28 | 2584.6 | 2535.27 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -458.723 | U 1 | 1.54976 | 3.Unitaire | 15 | 0.0000270213 | U 1
1222523 | 112.97 | R-1 | 2490.3 | 2489.17 | 2590.3 | 2589.17 | 2540.3 | 2539.17 | 2540.3 | 2539.17 | 2493.3 | 2492.17 | 2587.3 | 2586.17 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -407.828 | U 1 | 0.0354906 | 3.Unitaire | 12 | 0.0000270213 | U 1
