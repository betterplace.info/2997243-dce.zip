Properties of the parts of a building model (IFC2X3), part 7 of 8

# IfcFlowSegment: Gaine circulaire:Circulaire - Té (96)
Name (Gaine circulaire:Circulaire - Té:...) | Length (mm) = Longueur (mm) | Arase inférieure à son extrémité amont (mm) = Arase inférieure avec isolant à son extrémité amont (mm) | Arase inférieure à son extrémité aval (mm) = Arase inférieure avec isolant à son extrémité aval (mm) | Arase supérieure à son extrémité amont (mm) = Arase supérieure avec isolant à son extrémité amont (mm) | Arase supérieure à son extrémité aval (mm) = Arase supérieure avec isolant à son extrémité aval (mm) | Élévation centrale de départ (mm) = Elévation du milieu (mm) | Élévation centrale de fin (mm) | Elévation de l'axe à son extrémité amont (mm) | Elévation de l'axe à son extrémité aval (mm) | Diamètre (mm) = Diamètre hydraulique (mm) | Taille | Abréviation du système | Classification du système | Nom du système | Surface (m2) | Type de système | Rugosité relative | Trajectoire critique | Débit (m3/s) | Facteur de frottement | Frottement (kg/m2/s2) | Nombre de Reynolds | Perte de pression (Pa) | Pression dynamique (Pa) | Tronçon | Vitesse (m/s) | Taille globale = Taille libre | Group
942660 | 13.3998 | 2684.92 | 2684.92 | 2934.92 | 2934.92 | 2809.92 | 2809.92 | 2809.92 | 2809.92 | 250 | 250ø | S | Soufflage | S 7 | 0.0105242 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 0.00761033 | 6.93184 | 10 | 3.39531 | 250 mmø | S 7 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
977152 | 1630.17 | 2642.5 | 2642.5 | 2957.5 | 2957.5 | 2800 | 2800 | 2800 | 2800 | 315 | 315ø | S | Soufflage | S 4 | 1.61322 | 0.Soufflage | 0 | yes | 0.1875 | 0.0219335 | 0.232842 | 50498.7 | 0.274283 | 3.48074 | 2 | 2.40597 | 315 mmø | S 4 | Données d'identification - AI_Zone CLIM: OPEN SPACE
1067529 | 631.41 | 2620 | 2620 | 2820 | 2820 | 2720 | 2720 | 2720 | 2720 | 200 | 200ø | S | Soufflage | S 4 | 0.396727 | 0.Soufflage | 0 | yes | 0.118056 | 0.0235436 | 0.896484 | 50077.9 | 0.292799 | 8.4911 | 6 | 3.75782 | 200 mmø | S 4 | Données d'identification - AI_Zone CLIM: OPEN SPACE
1067560 | 3082.85 | 2700 | 2700 | 2900 | 2900 | 2800 | 2800 | 2800 | 2800 | 200 | 200ø | S | Soufflage | S 4 | 1.93701 | 0.Soufflage | 0 | yes | 0.118056 | 0.0211158 | 0.896484 | 50077.8 | 2.76372 | 8.4911 | 5 | 3.75782 | 200 mmø | S 4 | Données d'identification - AI_Zone CLIM: OPEN SPACE
1067623 | 52.8203 | 2686.6 | 2660.19 | 2859.81 | 2833.4 | 2773.21 | 2746.79 | 2773.21 | 2746.79 | 200 | 200ø | S | Soufflage | S 4 | 0.033188 | 0.Soufflage | 0 | yes | 0.118056 | 0.0211158 | 0.896484 | 50077.9 | 0.0473526 | 8.4911 | 5 | 3.75782 | 200 mmø | S 4 | Données d'identification - AI_Zone CLIM: OPEN SPACE; Contraintes - Inclinaison: 0.57735
1067668 | 52.8203 | 2686.6 | 2660.19 | 2859.81 | 2833.4 | 2773.21 | 2746.79 | 2773.21 | 2746.79 | 200 | 200ø | S | Soufflage | S 4 | 0.033188 | 0.Soufflage | 0 | yes | 0.0763889 | 0.0235436 | 0.418499 | 32403.3 | 0.0221052 | 3.5551 | 6 | 2.43153 | 200 mmø | S 4 | Données d'identification - AI_Zone CLIM: OPEN SPACE; Contraintes - Inclinaison: 0.57735
1155402 | 166.025 | 2683.25 | 2600.24 | 2899.76 | 2816.75 | 2791.51 | 2708.49 | 2791.51 | 2708.49 | 250 | 250ø | S | Soufflage | S 2 | 0.130396 | 0.Soufflage | 0 | yes | 0.111111 | 0.0226683 | 0.279347 | 37705.7 | 0.0463788 | 3.08082 | 6 | 2.26354 | 250 mmø | S 2 | Contraintes - Inclinaison: 0.57735
1155444 | 184.271 | 2550 | 2550 | 2800 | 2800 | 2675 | 2675 | 2675 | 2675 | 250 | 250ø | S | Soufflage | S 3 | 0.144726 | 0.Soufflage |  |  |  |  |  |  |  |  |  |  | 250 mmø | S 3
1155598 | 156.108 | 2627.74 | 2561.77 | 2913.23 | 2847.26 | 2704.51 | 2770.49 | 2770.49 | 2704.51 | 315 | 315ø | S | Soufflage | S 4 | 0.154484 | 0.Soufflage | 0 | yes | 0.1875 | 0.0210717 | 0.232842 | 50498.7 | 0.0363484 | 3.48074 | 1 | 2.40597 | 315 mmø | S 4 | Contraintes - Inclinaison: 0.466308
1155847 | 748.238 | 2517.5 | 2517.5 | 2832.5 | 2832.5 | 2675 | 2675 | 2675 | 2675 | 315 | 315ø | S | Soufflage | S 5 | 0.740458 | 0.Soufflage | 0 | no | 0.0416666 | 0.0306904 | 0.0167471 | 11221.9 | 0.0125308 | 0.171888 | 1 | 0.53466 | 315 mmø | S 5
1156093 | 6.8 | 2575 | 2575 | 2775 | 2775 | 2675 | 2675 | 2675 | 2675 | 200 | 200ø | VMC | Extraction d'air | VMC 6 | 0.00427256 | 0.Extraction (VMC) | 0 | no | 0.0416667 | 0.0273957 | 0.144884 | 17674.5 | 0.000985214 | 1.05772 | 1 | 1.32629 | 200 mmø | VMC 6
1156173 | 6.8 | 2575 | 2575 | 2775 | 2775 | 2675 | 2675 | 2675 | 2675 | 200 | 200ø | VMC | Extraction d'air | VMC 7 | 0.00427256 | 0.Extraction (VMC) | 0 | no | 0.0416667 | 0.0273957 | 0.144884 | 17674.5 | 0.000985214 | 1.05772 | 1 | 1.32629 | 200 mmø | VMC 7
1156204 | 6.8 | 2575 | 2575 | 2775 | 2775 | 2675 | 2675 | 2675 | 2675 | 200 | 200ø | VMC | Extraction d'air | VMC 9 | 0.00427256 | 0.Extraction (VMC) | 0 | no | 0.0416667 | 0.0273957 | 0.144884 | 17674.5 | 0.000985214 | 1.05772 | 1 | 1.32629 | 200 mmø | VMC 9
1156289 | 6.8 | 2575 | 2575 | 2775 | 2775 | 2675 | 2675 | 2675 | 2675 | 200 | 200ø | VMC | Extraction d'air | VMC 11 | 0.00427256 | 0.Extraction (VMC) | 0 | no | 0.0416667 | 0.0273957 | 0.144884 | 17674.5 | 0.000985214 | 1.05772 | 1 | 1.32629 | 200 mmø | VMC 11
1179252 | 149.218 | 2735.82 | 2586.6 | 2735.82 | 2586.6 | 2586.6 | 2735.82 | 2735.82 | 2586.6 | 125 | 125ø | VMC | Extraction d'air | VMC 5 | 0.0585978 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.0245118 | 0.623866 | 26 | 1.01859 | 125 mmø | VMC 5
1179254 | 21.2391 | 2798.32 | 2798.32 | 2923.32 | 2923.32 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 125 | 125ø | VMC | Extraction d'air | VMC 5 | 0.00834058 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.00348891 | 0.623866 | 26 | 1.01859 | 125 mmø | VMC 8; VMC 5
1200471 | 1086.29 | 2670 | 2670 | 2870 | 2870 | 2770 | 2770 | 2770 | 2770 | 200 | 200ø | S | Soufflage | S 4 | 0.682539 | 0.Soufflage | 0 | yes | 0.0347222 | 0.0286733 | 0.105306 | 14728.8 | 0.0686613 | 0.734525 | 8 | 1.10524 | 200 mmø | S 4 | Données d'identification - AI_Zone CLIM: OPEN SPACE
1200513 | 63.2501 | 2696.59 | 2680.22 | 2889.78 | 2873.41 | 2793.19 | 2776.81 | 2793.19 | 2776.81 | 200 | 200ø | S | Soufflage | S 4 | 0.0397412 | 0.Soufflage | 0 | yes | 0.0347222 | 0.0286733 | 0.105306 | 14728.8 | 0.00666064 | 0.734525 | 7 | 1.10524 | 200 mmø | S 4 | Contraintes - Inclinaison: 0.267949
1216414 | 68.0404 | 2658.39 | 2610.28 | 2835.17 | 2787.05 | 2746.78 | 2698.66 | 2746.78 | 2698.66 | 250 | 250ø | S | Soufflage | S 1 | 0.0534388 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 0.038643 | 6.93184 | 10 | 3.3953 | 250 mmø | S 1 | Contraintes - Inclinaison: 1
1216434 | 564.369 | 2500.44 | 2500.44 | 2750.44 | 2750.44 | 2625.44 | 2625.44 | 2625.44 | 2625.44 | 250 | 250ø | S | Soufflage | S 1 | 0.443254 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 0.320529 | 6.93184 | 10 | 3.3953 | 250 mmø | S 1
1216444 | 53.7848 | 2648.31 | 2610.28 | 2825.08 | 2787.05 | 2698.66 | 2736.7 | 2736.7 | 2698.66 | 250 | 250ø | S | Soufflage | S 1 | 0.0422425 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 0.0305467 | 6.93184 | 10 | 3.3953 | 250 mmø | S 1 | Contraintes - Inclinaison: 1
1216750 | 524.987 | 2780.82 | 2780.82 | 2940.82 | 2940.82 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 160 | 160ø | VMC | Extraction d'air | VMC 2 | 0.263887 | 0.Extraction (VMC) | 0 | no | 0.0375 | 0.0266008 | 0.347751 | 19883.9 | 0.182565 | 2.09167 | 4 | 1.8651 | 160 mmø | VMC 2
1216772 | 149.077 | 2735.68 | 2586.6 | 2735.68 | 2586.6 | 2586.6 | 2735.68 | 2735.68 | 2586.6 | 125 | 125ø | VMC | Extraction d'air | VMC 3 | 0.0585422 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.0244886 | 0.623866 | 27 | 1.01859 | 125 mmø | VMC 3
1216774 | 2201.18 | 2798.32 | 2798.18 | 2923.32 | 2923.18 | 2860.68 | 2860.82 | 2860.82 | 2860.68 | 125 | 125ø | VMC | Extraction d'air | VMC 3 | 0.864401 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.361584 | 0.623866 | 27 | 1.01859 | 125 mmø | VMC 2; VMC 3 | Contraintes - Inclinaison: 0.0000643393
1217153 | 320.553 | 2780.82 | 2780.82 | 2940.82 | 2940.82 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 160 | 160ø | VMC | Extraction d'air | VMC 2 | 0.161127 | 0.Extraction (VMC) | 0 | no | 0.0625 | 0.0234117 | 0.850166 | 33139.8 | 0.272531 | 5.8102 | 6 | 3.10849 | 160 mmø | VMC 2
1228922 | 3315 | 2757.5 | 2757.5 | 2882.5 | 2882.5 | 2820 | 2820 | 2820 | 2820 | 125 | 125ø | S | Soufflage | S 1 | 1.3018 | 0.Soufflage | 0 | no | 0.0277778 | 0.0269573 | 0.664403 | 18852.8 | 2.2025 | 3.08082 | 2 | 2.26354 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
1239700 | 64.0836 | 2700 | 2700 | 2900 | 2900 | 2800 | 2800 | 2800 | 2800 | 200 | 200ø | S | Soufflage | S 4 | 0.0402649 | 0.Soufflage | 0 | yes | 0.0347222 | 0.0286733 | 0.105306 | 14728.8 | 0.00674841 | 0.734525 | 7 | 1.10524 | 200 mmø | S 4 | Données d'identification - AI_Zone CLIM: OPEN SPACE

# IfcFlowSegment: Gaine rectangulaire:Goulotte (29)
In: RDC
Type - Autre - Catégorie: Gaine; Nom de la famille: Gaine rectangulaire
Type - Données d'identification - Sous-projet: Gaine; Nom du type: Goulotte
Type - Génie climatique - Rugosité: 0.09144 mm
Pset_DistributionFlowElementCommon - Reference: Goulotte; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Autre - Famille: Gaine rectangulaire; Famille et type: Gaine rectangulaire: Goulotte; ID du type: 802986; Type: Goulotte
Contraintes - Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: RDC
Données d'identification - Sous-projet: 02_ELE
Génie climatique - Verrouillage de la taille: no; Abréviation du système: GEN; Classification du système: Soufflage; Type de système: 0.Goulotte
Génie climatique - Débit - Facteur de frottement: 0; Nombre de Reynolds: 0; Trajectoire critique: no; Débit: 0 m3/s; Débit supplémentaire: 0 m3/s; Diamètre hydraulique: 72.2222 mm; Frottement: 0 kg/m2/s2; Perte de pression: 0 Pa; Pression dynamique: 0 Pa; Vitesse: 0 m/s
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Revêtement - Epaisseur du revêtement: 0 mm
Name (Gaine rectangulaire:Goulotte:...) | Length (mm) | Arase inférieure à son extrémité amont (mm) = Arase inférieure avec isolant à son extrémité amont (mm) | Arase inférieure à son extrémité aval (mm) = Arase inférieure avec isolant à son extrémité aval (mm) | Arase supérieure à son extrémité amont (mm) = Arase supérieure avec isolant à son extrémité amont (mm) | Arase supérieure à son extrémité aval (mm) = Arase supérieure avec isolant à son extrémité aval (mm) | Élévation centrale de départ (mm) = Elévation du milieu (mm) | Élévation centrale de fin (mm) | Elévation de l'axe à son extrémité amont (mm) | Elévation de l'axe à son extrémité aval (mm) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | Taille | Nom du système = Group | Surface (m2) | Rugosité relative | Tronçon | Taille globale = Taille libre
1156963 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 4730 | 50x130 | GEN 1 | 1.7028 | 0 | 3 | 50 mmx130 mm
1156970 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 6543.43 | 50x130 | GEN 1 | 2.35563 | 0 | 2 | 50 mmx130 mm
1156978 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 4510 | 50x130 | GEN 1 | 1.6236 | 0 | 2 | 50 mmx130 mm
1157542 | 2070 | 2500 | 430 | 2500 | 430 | 430 | 2500 | 2500 | 430 | 130 | 50 | 2070 | 50x130 | GEN 1 | 0.7452 | 0 | 3 | 50 mmx130 mm
1157755 | 2265 | 2780 | 515 | 2780 | 515 | 515 | 2780 | 2780 | 515 | 130 | 50 | 2265 | 50x130 | GEN 1 | 0.8154 | 0 | 5 | 50 mmx130 mm
1158407 | 2547 | 2547 | 0 | 2547 | 0 | 0 | 2547 | 2547 | 0 | 130 | 50 | 2547 | 50x130 | GEN 2 | 0.916919 | 0.00126609 | 1 | 50 mmx130 mm
1158798 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 8410 | 50x130 | GEN 1 | 3.0276 | 0 | 1 | 50 mmx130 mm
1158829 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 5467.78 | 50x130 | GEN 1 | 1.9684 | 0 | 1 | 50 mmx130 mm
1159528 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 2469.15 | 50x130 | GEN 3 | 0.888894 | 0 | 2 | 50 mmx130 mm
1159558 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 4586.57 | 50x130 | GEN 3 | 1.65116 | 0 | 4 | 50 mmx130 mm
1159618 | 2070 | 2500 | 430 | 2500 | 430 | 430 | 2500 | 2500 | 430 | 130 | 50 | 2070 | 50x130 | GEN 3 | 0.7452 | 0 | 1 | 50 mmx130 mm
1160619 | 2500 | 2500 | 0 | 2500 | 0 | 0 | 2500 | 2500 | 0 | 130 | 50 | 2500 | 50x130 | GEN 4 | 0.9 | 0.00126609 | 1 | 50 mmx130 mm
1161631 | 2070 | 2500 | 430 | 2500 | 430 | 430 | 2500 | 2500 | 430 | 130 | 50 | 2070 | 50x130 | GEN 5 | 0.7452 | 0.00126609 | 1 | 50 mmx130 mm
1197192 | 50 | 651.794 | 651.794 | 701.794 | 701.794 | 676.794 | 676.794 | 676.794 | 676.794 | 50 | 130 | 1454.72 | 130x50 | GEN 1 | 0.523701 | 0 | 4 | 130 mmx50 mm
1197256 | 236.794 | 626.794 | 390 | 626.794 | 390 | 626.794 | 390 | 626.794 | 390 | 50 | 130 | 236.794 | 130x50 | GEN 1 | 0.0852459 | 0 | 4 | 130 mmx50 mm
1197352 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 8701.56 | 50x130 | GEN 1 | 3.13256 | 0 | 3 | 50 mmx130 mm
1197429 | 50 | 651.794 | 651.794 | 701.794 | 701.794 | 676.794 | 676.794 | 676.794 | 676.794 | 50 | 130 | 3304.94 | 130x50 | GEN 1 | 1.18978 | 0 | 4 | 130 mmx50 mm
1197550 | 50 | 651.794 | 651.794 | 701.794 | 701.794 | 676.794 | 676.794 | 676.794 | 676.794 | 50 | 130 | 2692.01 | 130x50 | GEN 6 | 0.969123 | 0 | 1 | 130 mmx50 mm
1197561 | 50 | 651.794 | 651.794 | 701.794 | 701.794 | 676.794 | 676.794 | 676.794 | 676.794 | 50 | 130 | 2856.78 | 130x50 | GEN 6 | 1.02844 | 0 | 1 | 130 mmx50 mm
1197567 | 50 | 651.794 | 651.794 | 701.794 | 701.794 | 676.794 | 676.794 | 676.794 | 676.794 | 50 | 130 | 3124.94 | 130x50 | GEN 6 | 1.12498 | 0 | 1 | 130 mmx50 mm
1197685 | 50 | 651.794 | 651.794 | 701.794 | 701.794 | 676.794 | 676.794 | 676.794 | 676.794 | 50 | 130 | 2050 | 130x50 | GEN 3 | 0.738001 | 0 | 5 | 130 mmx50 mm
1197686 | 236.797 | 626.795 | 389.999 | 626.798 | 390.001 | 626.797 | 390 | 626.797 | 390 | 50 | 130 | 236.797 | 130x50 | GEN 3 | 0.0852468 | 0 | 5 | 130 mmx50 mm
1197755 | 50 | 651.794 | 651.794 | 701.794 | 701.794 | 676.794 | 676.794 | 676.794 | 676.794 | 50 | 130 | 2049.9 | 130x50 | GEN 3 | 0.737965 | 0 | 6 | 130 mmx50 mm
1197862 | 50 | 651.794 | 651.794 | 701.794 | 701.794 | 676.794 | 676.794 | 676.794 | 676.794 | 50 | 130 | 1890 | 130x50 | GEN 3 | 0.6804 | 0 | 7 | 130 mmx50 mm
1197973 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 3133.33 | 50x130 | GEN 3 | 1.128 | 0 | 3 | 50 mmx130 mm
1198115 | 236.792 | 626.791 | 389.999 | 626.793 | 390.001 | 626.792 | 390 | 626.792 | 390 | 50 | 130 | 236.792 | 130x50 | GEN 3 | 0.0852451 | 0 | 6 | 130 mmx50 mm
1198145 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 1243.78 | 50x130 | GEN 3 | 0.447759 | 0 | 2 | 50 mmx130 mm
1198216 | 236.794 | 626.794 | 390 | 626.794 | 390 | 626.794 | 390 | 626.794 | 390 | 50 | 130 | 236.794 | 130x50 | GEN 3 | 0.0852459 | 0 | 7 | 130 mmx50 mm
1198239 | 130 | 235 | 235 | 365 | 365 | 300 | 300 | 300 | 300 | 130 | 50 | 2334.14 | 50x130 | GEN 3 | 0.84029 | 0 | 1 | 50 mmx130 mm

# IfcFlowSegment: Gaine rectangulaire:Rectangulaire - Piquage (2)
In: RDC
Type - Autre - Catégorie: Gaine; Nom de la famille: Gaine rectangulaire
Type - Données d'identification - Sous-projet: Gaine; Nom du type: Rectangulaire - Piquage
Type - Génie climatique - Rugosité: 0.09144 mm
Pset_DistributionFlowElementCommon - Reference: Rectangulaire - Piquage; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 300 mm; sets with these values: 2
Autre - Famille: Gaine rectangulaire; Famille et type: Gaine rectangulaire: Rectangulaire - Piquage; ID du type: 805995; Type: Rectangulaire - Piquage
Contraintes - Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: RDC; Arase inférieure à son extrémité amont: 97.3 mm; Arase inférieure à son extrémité aval: 97.3 mm; Arase supérieure à son extrémité amont: 397.3 mm; Arase supérieure à son extrémité aval: 397.3 mm; Élévation centrale de départ: 247.3 mm; Élévation centrale de fin: 247.3 mm; Elévation de l'axe à son extrémité amont: 247.3 mm; Elévation de l'axe à son extrémité aval: 247.3 mm; Elévation du milieu: 247.3 mm
Cotes - Hauteur: 300 mm; Largeur: 300 mm; Longueur: 130 mm; Taille: 300x300
Données d'identification - Sous-projet: 01_CVC; AI_Preneur: SHLMR
Génie climatique - Verrouillage de la taille: no; Classification du système: Soufflage; Surface: 0.156 m2; Type de système: VMC
Génie climatique - Débit - Trajectoire critique: no; Tronçon: 1; Débit: 0.078 m3/s; Débit supplémentaire: 0 m3/s; Diamètre hydraulique: 300 mm; Facteur de frottement: 0.0280528; Frottement: 0.0422328 kg/m2/s2; Nombre de Reynolds: 17324.2; Perte de pression: 0.00549027 Pa; Pression dynamique: 0.451643 Pa; Rugosité relative: 0.0003048; Vitesse: 0.866666 m/s
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Arase inférieure avec isolant à son extrémité amont: 97.3 mm; Arase inférieure avec isolant à son extrémité aval: 97.3 mm; Arase supérieure avec isolant à son extrémité amont: 397.3 mm; Arase supérieure avec isolant à son extrémité aval: 397.3 mm; Taille globale: 300 mmx300 mm
Revêtement - Epaisseur du revêtement: 0 mm; Taille libre: 300 mmx300 mm
Name (Gaine rectangulaire:Rectangulaire - Piquage:...) | Nom du système = Group
976558 | Génie climatique VMC 1
976624 | Génie climatique VMC 2

# IfcFlowTerminal: AI_Acc gaine_CCF Circulaire:D200, AI_Acc gaine_CCF Circulaire:D200:1239698
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Accessoire de gaine; Longueur: 1000 mm; Longueur 1: 155 mm; Longueur 2: 50 mm; Longueur 3: 240 mm; Longueur 4: 10 mm; Longueur 5: 10 mm; Longueur 6: 10 mm; Longueur 7: 880 mm; Longueur 8: 675 mm; Nom de la famille: AI_Acc gaine_CCF Circulaire; Rayon 1: 50 mm
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - D: 200 mm; D1: 200 mm; De: 250 mm; L: 445 mm; R: 100 mm; R1: 100 mm; R2: 125 mm
Type - Données d'identification - Nom du type: D200; Sous-projet: Famille : Accessoire de gaine : AI_Acc gaine_CCF Circulaire
Pset_DistributionFlowElementCommon - Reference: D200; sets with these values: 2
Autre - Famille: AI_Acc gaine_CCF Circulaire; Famille et type: AI_Acc gaine_CCF Circulaire: D200; ID du type: 1239538; Type: D200
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 2800 mm
Cotes - Taille: 200ø-200ø; Volume: 0.0197745 m3
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 01_CVC; Identifiant: 1
Génie climatique - Type de système: 0.Soufflage; Abréviation du système: S; Classification du système: Soufflage,Contrôles; Nom du système: S 4; Perte de pression: 0 Pa
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 200 mmø-200 mmø
Revêtement - Epaisseur du revêtement: 0 mm; Taille libre: 200 mmø-200 mmø
Group: S 4

# IfcFlowTerminal: AI_Appareil sanitaire_Siphon de sol_Sortie verticale:Siphon de sol (2)
In: RDC
Type - Material: Acier Inox
Type - Autre - Catégorie: Appareils sanitaires; Nom de la famille: AI_Appareil sanitaire_Siphon de sol_Sortie verticale
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Siphon de sol; Sous-projet: Famille : Appareils sanitaires : AI_Appareil sanitaire_Siphon de sol_Sortie verticale
Type - Visibilité - AI_Cuvette Siphoïde: no; AI_Siphon de sol: yes
Pset_DistributionFlowElementCommon - Reference: Siphon de sol; sets with these values: 2
Autre - Famille: AI_Appareil sanitaire_Siphon de sol_Sortie verticale; Famille et type: AI_Appareil sanitaire_Siphon de sol_Sortie verticale: Siphon de sol; ID du type: 1206276; Type: Siphon de sol
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 0 mm; Élévation par rapport au niveau: 0 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.0753779 m2; Volume: 0.00162347 m3
Données d'identification - Sous-projet: 03_PLB
Génie climatique - Type de système: 3.Eaux Usées; Abréviation du système: EU; Classification du système: Sanitaire
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Appareil sanitaire_Siphon de sol_Sortie verticale:Siphon de sol:...) | Identifiant | Nom du système = Group
1213432 | 4 | EU 9
1213677 | 5 | EU 8

# IfcFlowTerminal: AI_Bouche aération_Circulaire Extraction:ø125 mm (17)
In: RDC
Type - Material: Metal - AIRZONE - Aluminium - Brushed, Metal - AIRZONE - Extruded Aluminium - White (RAL 9010)
Type - Autre - Catégorie: Bouche d'aération; Nom de la famille: AI_Bouche aération_Circulaire Extraction
Type - Propriétés du modèle - Disclaimer: All information provided in this model is reviewed before being published. However, Airzone cannot guarantee this model is error-free, therefore users are strongly encouraged to check for technical documentation and updates; Revit Model Version: 1.0
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données - Ak: 1.4; c1: 0.001601; c2: -3.153; c3: -153.1; c4: -77.45; c5: 82.34; c6: -6.299; c7: 0.01485; c8: -0.8079
Type - Cotes - Duct Diameter: 125 mm; Neck Length: 45.4 mm
Type - Général - Edition number: 1; Nominal height: 0 mm; Nominal width: 0 mm; Brand url: http://www.airzone.es/en/; Design country: Spain; Manufacturer country: Spain; Manufacturer name: Airzone; Product family: AirQ; Product group: Air diffusor; Product SKU: AirQ_DFCI_WN; QR code: http://bimobject.com/airzone/product/AirQ_DFCI_WN; Region Africa: MA; Region Europe: AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; Weight Net (Kg): 0
Type - Données d'identification - Compatible Accesories: Insulated flexible duct (TFTA) and non-insulated flexible duct (TFST); Description: Round diffuser; Fabricant: AIRZONE; Fixing: Security mechanical attachment. Mounting bracket; Installation instructions: http://doc.airzone.es/producto/actuales/AirQ/AirQ_DFCI_A4_EN.pdf; Long Description: Round diffuser DFCI to supply air in 4 directions that enables the air supply. Easy to disassemble to facilitate its maintenance. Designed to be installed in ceiling.; Modèle: DFCI150BC; Nom du type: ø125 mm; Numéro OmniClass: 23.75.70.21.27.11; Product certification: http://doc.airzone.es/BIM/AirQ/Airzone_air_diffusion_Certificates.zip; Product Code: DFCI150BC; Product Comments: Refer to technical documentation for further details; Product Documentation Download URL: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Product url: http://www.airzone.es/en/; Sous-projet: Famille : Bouche d'aération : AI_Bouche aération_Circulaire Extraction; Technical description: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Titre OmniClass: Diffusers, Registers, and Grilles; Type Image Comments: Image available in product documentation download; URL: www.airzone.es
Type - Matériaux et finitions - Accessories Material: Metal - AIRZONE - Aluminium - Brushed; Main Material: Metal - AIRZONE - Extruded Aluminium - White (RAL 9010); Finish: White (RAL 9010); Material main: Aluminium; Material secondary: Galvanized steel
Type - Génie climatique - Débit - Débit max.: 0.416667 m3/s; Débit min.: 0.0416667 m3/s; Effective Area: 0.014 m2
Type - Pset_AirTerminalTypeCommon - EffectiveArea: 0.014 m2
Type - Pset_ManufacturerTypeInformation - Manufacturer: AIRZONE
Pset_DistributionFlowElementCommon - Reference: ø125 mm; sets with these values: 2
Autre - Type: ø125 mm; Famille: AI_Bouche aération_Circulaire Extraction; Famille et type: AI_Bouche aération_Circulaire Extraction: ø125 mm; ID du type: 874889
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - Surface: 0.0690994 m2; Taille: 125ø; Volume: 0.0012118 m3
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Classification du système: Extraction d'air
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Bouche aération_Circulaire Extraction:ø125 mm:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Q | Identifiant | Abréviation du système | Nom du système = Group | Type de système | Débit (m3/s) = Flow (m3/s) | Pressure Drop (Pa) | Sound Level in dB(A) | Throw Distance (mm) | Velocity (m/s)
923337 | 2500 | 45 | 23 | VMC | VMC 1 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857
923476 | 2500 | 45 | 24 | VMC | VMC 2 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857
923600 | 2500 | 45 | 25 | VMC | VMC 2 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857
923680 | 2500 | 45 | 26 | VMC | VMC 2 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857
924061 | 2618.47 | 45 | 29 | VMC | VMC 2 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857
924534 | 2860.82 | 45 | 31 | VMC | VMC 8 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857
941035 | 2539.08 | 45 | 32 | VMC | VMC 8 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857 | Données d'identification - AI_Phase: EXISTANT
941080 | 2539.08 | 45 | 33 | VMC | VMC 8 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857 | Données d'identification - AI_Phase: EXISTANT
941222 | 2539.08 | 45 | 34 | VMC | VMC 8 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857 | Données d'identification - AI_Phase: EXISTANT
941229 | 2539.08 | 45 | 35 | VMC | VMC 8 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857 | Données d'identification - AI_Phase: EXISTANT
941451 | 2539.08 | 45 | 36 | VMC | VMC 8 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857 | Données d'identification - AI_Phase: EXISTANT
941611 | 2539.08 | 90 | 37 | VMC | VMC 8 | 0.Extraction (VMC) | 0.025 | 4.48885 | -5 | 1018 | 1.78571 | Données d'identification - AI_Phase: EXISTANT
1064054 | 2645.21 | 50 | 58 |  |  |  | 0.0138889 | 1.38545 | -26 | 566 | 0.992063
1064063 | 2645.21 | 50 | 60 |  |  |  | 0.0138889 | 1.38545 | -26 | 566 | 0.992063
1064074 | 2645.21 | 50 | 62 |  |  |  | 0.0138889 | 1.38545 | -26 | 566 | 0.992063
1179251 | 2500 | 45 | 74 | VMC | VMC 5 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857
1216771 | 2500 | 45 | 75 | VMC | VMC 3 | 0.Extraction (VMC) | 0.0125 | 1.12221 | -30 | 509 | 0.892857

# IfcFlowTerminal: AI_Bouche aération_Circulaire Extraction:ø200 mm (4)
In: RDC
Type - Material: Metal - AIRZONE - Aluminium - Brushed, Metal - AIRZONE - Extruded Aluminium - White (RAL 9010)
Type - Autre - Catégorie: Bouche d'aération; Nom de la famille: AI_Bouche aération_Circulaire Extraction
Type - Propriétés du modèle - Disclaimer: All information provided in this model is reviewed before being published. However, Airzone cannot guarantee this model is error-free, therefore users are strongly encouraged to check for technical documentation and updates; Revit Model Version: 1.0
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données - Ak: 1.4; c1: 0.001601; c2: -3.153; c3: -153.1; c4: -77.45; c5: 82.34; c6: -6.299; c7: 0.01485; c8: -0.8079
Type - Cotes - Duct Diameter: 200 mm; Neck Length: 45.4 mm
Type - Général - Edition number: 1; Nominal height: 0 mm; Nominal width: 0 mm; Brand url: http://www.airzone.es/en/; Design country: Spain; Manufacturer country: Spain; Manufacturer name: Airzone; Product family: AirQ; Product group: Air diffusor; Product SKU: AirQ_DFCI_WN; QR code: http://bimobject.com/airzone/product/AirQ_DFCI_WN; Region Africa: MA; Region Europe: AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; Weight Net (Kg): 0
Type - Données d'identification - Sous-projet: Famille : Bouche d'aération : AI_Bouche aération_Circulaire Extraction; Compatible Accesories: Insulated flexible duct (TFTA) and non-insulated flexible duct (TFST); Description: Round diffuser; Fabricant: AIRZONE; Fixing: Security mechanical attachment. Mounting bracket; Installation instructions: http://doc.airzone.es/producto/actuales/AirQ/AirQ_DFCI_A4_EN.pdf; Long Description: Round diffuser DFCI to supply air in 4 directions that enables the air supply. Easy to disassemble to facilitate its maintenance. Designed to be installed in ceiling.; Modèle: DFCI150BC; Nom du type: ø200 mm; Numéro OmniClass: 23.75.70.21.27.11; Product certification: http://doc.airzone.es/BIM/AirQ/Airzone_air_diffusion_Certificates.zip; Product Code: DFCI150BC; Product Comments: Refer to technical documentation for further details; Product Documentation Download URL: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Product url: http://www.airzone.es/en/; Technical description: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Titre OmniClass: Diffusers, Registers, and Grilles; Type Image Comments: Image available in product documentation download; URL: www.airzone.es
Type - Matériaux et finitions - Accessories Material: Metal - AIRZONE - Aluminium - Brushed; Main Material: Metal - AIRZONE - Extruded Aluminium - White (RAL 9010); Finish: White (RAL 9010); Material main: Aluminium; Material secondary: Galvanized steel
Type - Génie climatique - Débit - Débit max.: 0.416667 m3/s; Débit min.: 0.0416667 m3/s; Effective Area: 0.014 m2
Type - Pset_AirTerminalTypeCommon - EffectiveArea: 0.014 m2
Type - Pset_ManufacturerTypeInformation - Manufacturer: AIRZONE
Pset_DistributionFlowElementCommon - Reference: ø200 mm; sets with these values: 2
Autre - Famille: AI_Bouche aération_Circulaire Extraction; Famille et type: AI_Bouche aération_Circulaire Extraction: ø200 mm; ID du type: 976474; Type: ø200 mm
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2675 mm; Élévation par rapport au niveau: 2675 mm; Hôte: Niveau : RDC
Données - Q: 150
Cotes - Surface: 0.128786 m2; Taille: 200ø; Volume: 0.00300688 m3
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Type de système: 0.Extraction (VMC); Abréviation du système: VMC; Classification du système: Extraction d'air
Génie climatique - Débit - Débit: 0.0416666 m3/s; Flow: 0.0416667 m3/s; Pressure Drop: 12.469 Pa; Sound Level in dB(A): 13; Throw Distance: 1697 mm; Velocity: 2.97619 m/s
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Bouche aération_Circulaire Extraction:ø200 mm:...) | Identifiant | Nom du système = Group
1156071 | 64 | VMC 6
1156172 | 66 | VMC 7
1156203 | 68 | VMC 9
1156288 | 72 | VMC 11

# IfcFlowTerminal: AI_Bouche aération_Circulaire Reprise:ø250 mm, AI_Bouche aération_Circulaire Reprise:ø250 mm:880858
In: RDC
Type - Material: Metal - AIRZONE - Aluminium - Brushed, Metal - AIRZONE - Extruded Aluminium - White (RAL 9010)
Type - Autre - Catégorie: Bouche d'aération; Nom de la famille: AI_Bouche aération_Circulaire Reprise
Type - Propriétés du modèle - Disclaimer: All information provided in this model is reviewed before being published. However, Airzone cannot guarantee this model is error-free, therefore users are strongly encouraged to check for technical documentation and updates; Revit Model Version: 1.0
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données - Ak: 1.4; c1: 0.001601; c2: -3.153; c3: -153.1; c4: -77.45; c5: 82.34; c6: -6.299; c7: 0.01485; c8: -0.8079
Type - Cotes - Duct Diameter: 250 mm; Neck Length: 45.4 mm
Type - Général - Edition number: 1; Nominal height: 0 mm; Nominal width: 0 mm; Brand url: http://www.airzone.es/en/; Design country: Spain; Manufacturer country: Spain; Manufacturer name: Airzone; Product family: AirQ; Product group: Air diffusor; Product SKU: AirQ_DFCI_WN; QR code: http://bimobject.com/airzone/product/AirQ_DFCI_WN; Region Africa: MA; Region Europe: AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; Weight Net (Kg): 0
Type - Données d'identification - Compatible Accesories: Insulated flexible duct (TFTA) and non-insulated flexible duct (TFST); Description: Round diffuser; Fabricant: AIRZONE; Fixing: Security mechanical attachment. Mounting bracket; Installation instructions: http://doc.airzone.es/producto/actuales/AirQ/AirQ_DFCI_A4_EN.pdf; Long Description: Round diffuser DFCI to supply air in 4 directions that enables the air supply. Easy to disassemble to facilitate its maintenance. Designed to be installed in ceiling.; Modèle: DFCI150BC; Nom du type: ø250 mm; Numéro OmniClass: 23.75.70.21.27.11; Product certification: http://doc.airzone.es/BIM/AirQ/Airzone_air_diffusion_Certificates.zip; Product Code: DFCI150BC; Product Comments: Refer to technical documentation for further details; Product Documentation Download URL: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Product url: http://www.airzone.es/en/; Sous-projet: Famille : Bouche d'aération : AI_Bouche aération_Circulaire Reprise; Technical description: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Titre OmniClass: Diffusers, Registers, and Grilles; Type Image Comments: Image available in product documentation download; URL: www.airzone.es
Type - Matériaux et finitions - Accessories Material: Metal - AIRZONE - Aluminium - Brushed; Main Material: Metal - AIRZONE - Extruded Aluminium - White (RAL 9010); Finish: White (RAL 9010); Material main: Aluminium; Material secondary: Galvanized steel
Type - Génie climatique - Débit - Débit max.: 0.416667 m3/s; Débit min.: 0.0416667 m3/s; Effective Area: 0.014 m2
Type - Pset_AirTerminalTypeCommon - EffectiveArea: 0.014 m2
Type - Pset_ManufacturerTypeInformation - Manufacturer: AIRZONE
Pset_DistributionFlowElementCommon - Reference: ø250 mm; sets with these values: 2
Autre - Famille: AI_Bouche aération_Circulaire Reprise; Famille et type: AI_Bouche aération_Circulaire Reprise: ø250 mm; ID du type: 874899; Type: ø250 mm
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2675 mm; Élévation par rapport au niveau: 2675 mm; Hôte: Niveau : RDC
Données - Q: 150
Cotes - Surface: 0.178389 m2; Taille: 250ø; Volume: 0.00465551 m3
Données d'identification - Sous-projet: 01_CVC; Identifiant: 12
Génie climatique - Type de système: 0.Soufflage; Abréviation du système: S; Classification du système: Reprise; Nom du système: S 3
Génie climatique - Débit - Flow: 0.0416667 m3/s; Pressure Drop: 12.469 Pa; Sound Level in dB(A): 13; Throw Distance: 1697 mm; Velocity: 2.97619 m/s
Phase de construction - Phase de création: Nouvelle construction
Group: S 3

# IfcFlowTerminal: AI_Bouche aération_Circulaire Reprise:ø315 mm, AI_Bouche aération_Circulaire Reprise:ø315 mm:880922
In: RDC
Type - Material: Metal - AIRZONE - Aluminium - Brushed, Metal - AIRZONE - Extruded Aluminium - White (RAL 9010)
Type - Autre - Catégorie: Bouche d'aération; Nom de la famille: AI_Bouche aération_Circulaire Reprise
Type - Propriétés du modèle - Disclaimer: All information provided in this model is reviewed before being published. However, Airzone cannot guarantee this model is error-free, therefore users are strongly encouraged to check for technical documentation and updates; Revit Model Version: 1.0
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données - Ak: 1.4; c1: 0.001601; c2: -3.153; c3: -153.1; c4: -77.45; c5: 82.34; c6: -6.299; c7: 0.01485; c8: -0.8079
Type - Cotes - Duct Diameter: 315 mm; Neck Length: 45.4 mm
Type - Général - Edition number: 1; Nominal height: 0 mm; Nominal width: 0 mm; Brand url: http://www.airzone.es/en/; Design country: Spain; Manufacturer country: Spain; Manufacturer name: Airzone; Product family: AirQ; Product group: Air diffusor; Product SKU: AirQ_DFCI_WN; QR code: http://bimobject.com/airzone/product/AirQ_DFCI_WN; Region Africa: MA; Region Europe: AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; Weight Net (Kg): 0
Type - Données d'identification - Sous-projet: Famille : Bouche d'aération : AI_Bouche aération_Circulaire Reprise; Compatible Accesories: Insulated flexible duct (TFTA) and non-insulated flexible duct (TFST); Description: Round diffuser; Fabricant: AIRZONE; Fixing: Security mechanical attachment. Mounting bracket; Installation instructions: http://doc.airzone.es/producto/actuales/AirQ/AirQ_DFCI_A4_EN.pdf; Long Description: Round diffuser DFCI to supply air in 4 directions that enables the air supply. Easy to disassemble to facilitate its maintenance. Designed to be installed in ceiling.; Modèle: DFCI150BC; Nom du type: ø315 mm; Numéro OmniClass: 23.75.70.21.27.11; Product certification: http://doc.airzone.es/BIM/AirQ/Airzone_air_diffusion_Certificates.zip; Product Code: DFCI150BC; Product Comments: Refer to technical documentation for further details; Product Documentation Download URL: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Product url: http://www.airzone.es/en/; Technical description: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Titre OmniClass: Diffusers, Registers, and Grilles; Type Image Comments: Image available in product documentation download; URL: www.airzone.es
Type - Matériaux et finitions - Accessories Material: Metal - AIRZONE - Aluminium - Brushed; Main Material: Metal - AIRZONE - Extruded Aluminium - White (RAL 9010); Finish: White (RAL 9010); Material main: Aluminium; Material secondary: Galvanized steel
Type - Génie climatique - Débit - Débit max.: 0.416667 m3/s; Débit min.: 0.0416667 m3/s; Effective Area: 0.014 m2
Type - Pset_AirTerminalTypeCommon - EffectiveArea: 0.014 m2
Type - Pset_ManufacturerTypeInformation - Manufacturer: AIRZONE
Pset_DistributionFlowElementCommon - Reference: ø315 mm; sets with these values: 2
Autre - Famille: AI_Bouche aération_Circulaire Reprise; Famille et type: AI_Bouche aération_Circulaire Reprise: ø315 mm; ID du type: 977019; Type: ø315 mm
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2675 mm; Élévation par rapport au niveau: 2675 mm; Hôte: Niveau : RDC
Données - Q: 150
Cotes - Surface: 0.254628 m2; Taille: 315ø; Volume: 0.00733968 m3
Données d'identification - Sous-projet: 01_CVC; Identifiant: 13
Génie climatique - Type de système: 0.Soufflage; Abréviation du système: S; Classification du système: Reprise; Nom du système: S 5
Génie climatique - Débit - Débit: 0.0416667 m3/s; Flow: 0.0416667 m3/s; Pressure Drop: 12.469 Pa; Sound Level in dB(A): 13; Throw Distance: 1697 mm; Velocity: 2.97619 m/s
Phase de construction - Phase de création: Nouvelle construction
Group: S 5

# IfcFlowTerminal: AI_Bouche aération_Circulaire Soufflage:ø125 mm (8)
In: RDC
Type - Material: Metal - AIRZONE - Aluminium - Brushed, Metal - AIRZONE - Extruded Aluminium - White (RAL 9010)
Type - Autre - Catégorie: Bouche d'aération; Nom de la famille: AI_Bouche aération_Circulaire Soufflage
Type - Propriétés du modèle - Disclaimer: All information provided in this model is reviewed before being published. However, Airzone cannot guarantee this model is error-free, therefore users are strongly encouraged to check for technical documentation and updates; Revit Model Version: 1.0
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données - Ak: 1.4; c1: 0.001601; c2: -3.153; c3: -153.1; c4: -77.45; c5: 82.34; c6: -6.299; c7: 0.01485; c8: -0.8079
Type - Cotes - Duct Diameter: 125 mm; Neck Length: 45.4 mm
Type - Général - Brand url: http://www.airzone.es/en/; Design country: Spain; Edition number: 1; Manufacturer country: Spain; Manufacturer name: Airzone; Nominal height: 0 mm; Nominal width: 0 mm; Product family: AirQ; Product group: Air diffusor; Product SKU: AirQ_DFCI_WN; QR code: http://bimobject.com/airzone/product/AirQ_DFCI_WN; Region Africa: MA; Region Europe: AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; Weight Net (Kg): 0
Type - Données d'identification - Compatible Accesories: Insulated flexible duct (TFTA) and non-insulated flexible duct (TFST); Description: Round diffuser; Fabricant: AIRZONE; Fixing: Security mechanical attachment. Mounting bracket; Installation instructions: http://doc.airzone.es/producto/actuales/AirQ/AirQ_DFCI_A4_EN.pdf; Long Description: Round diffuser DFCI to supply air in 4 directions that enables the air supply. Easy to disassemble to facilitate its maintenance. Designed to be installed in ceiling.; Modèle: DFCI150BC; Nom du type: ø125 mm; Numéro OmniClass: 23.75.70.21.27.11; Product certification: http://doc.airzone.es/BIM/AirQ/Airzone_air_diffusion_Certificates.zip; Product Code: DFCI150BC; Product Comments: Refer to technical documentation for further details; Product Documentation Download URL: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Product url: http://www.airzone.es/en/; Sous-projet: Famille : Bouche d'aération : AI_Bouche aération_Circulaire Soufflage; Technical description: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Titre OmniClass: Diffusers, Registers, and Grilles; Type Image Comments: Image available in product documentation download; URL: www.airzone.es
Type - Matériaux et finitions - Accessories Material: Metal - AIRZONE - Aluminium - Brushed; Finish: White (RAL 9010); Main Material: Metal - AIRZONE - Extruded Aluminium - White (RAL 9010); Material main: Aluminium; Material secondary: Galvanized steel
Type - Génie climatique - Débit - Débit max.: 0.416667 m3/s; Débit min.: 0.0416667 m3/s; Effective Area: 0.014 m2
Type - Pset_AirTerminalTypeCommon - EffectiveArea: 0.014 m2
Type - Pset_ManufacturerTypeInformation - Manufacturer: AIRZONE
Pset_DistributionFlowElementCommon - Reference: ø125 mm; sets with these values: 2
Autre - Famille: AI_Bouche aération_Circulaire Soufflage; Famille et type: AI_Bouche aération_Circulaire Soufflage: ø125 mm; ID du type: 874893; Type: ø125 mm
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2645.21 mm; Élévation par rapport au niveau: 2645.21 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.0690994 m2; Taille: 125ø; Volume: 0.0012118 m3
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Classification du système: Soufflage
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Bouche aération_Circulaire Soufflage:ø125 mm:...) | Q | Identifiant | Type de système | Abréviation du système | Nom du système = Group | Débit (m3/s) = Flow (m3/s) | Pressure Drop (Pa) | Sound Level in dB(A) | Throw Distance (mm) | Velocity (m/s)
875088 | 150 | 1 | 0.Soufflage | S | S 1 | 0.0416667 | 12.469 | 13 | 1697 | 2.97619
875186 | 150 | 2 | 0.Soufflage | S | S 1 | 0.0416667 | 12.469 | 13 | 1697 | 2.97619
875204 | 150 | 3 | 0.Soufflage | S | S 1 | 0.0416667 | 12.469 | 13 | 1697 | 2.97619
875226 | 50 | 4 | 0.Soufflage | S | S 1 | 0.0138889 | 1.38545 | -26 | 566 | 0.992063
875244 | 50 | 5 | 0.Soufflage | S | S 1 | 0.0138889 | 1.38545 | -26 | 566 | 0.992063
1064053 | 50 | 57 |  |  |  | 0.0138889 | 1.38545 | -26 | 566 | 0.992063
1064062 | 50 | 59 |  |  |  | 0.0138889 | 1.38545 | -26 | 566 | 0.992063
1064073 | 50 | 61 |  |  |  | 0.0138889 | 1.38545 | -26 | 566 | 0.992063

# IfcFlowTerminal: AI_Bouche aération_Circulaire Soufflage:ø200 mm (4)
In: RDC
Type - Material: Metal - AIRZONE - Aluminium - Brushed, Metal - AIRZONE - Extruded Aluminium - White (RAL 9010)
Type - Autre - Catégorie: Bouche d'aération; Nom de la famille: AI_Bouche aération_Circulaire Soufflage
Type - Propriétés du modèle - Disclaimer: All information provided in this model is reviewed before being published. However, Airzone cannot guarantee this model is error-free, therefore users are strongly encouraged to check for technical documentation and updates; Revit Model Version: 1.0
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données - Ak: 1.4; c1: 0.001601; c2: -3.153; c3: -153.1; c4: -77.45; c5: 82.34; c6: -6.299; c7: 0.01485; c8: -0.8079
Type - Cotes - Duct Diameter: 200 mm; Neck Length: 45.4 mm
Type - Général - Edition number: 1; Nominal height: 0 mm; Nominal width: 0 mm; Brand url: http://www.airzone.es/en/; Design country: Spain; Manufacturer country: Spain; Manufacturer name: Airzone; Product family: AirQ; Product group: Air diffusor; Product SKU: AirQ_DFCI_WN; QR code: http://bimobject.com/airzone/product/AirQ_DFCI_WN; Region Africa: MA; Region Europe: AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; Weight Net (Kg): 0
Type - Données d'identification - Sous-projet: Famille : Bouche d'aération : AI_Bouche aération_Circulaire Soufflage; Compatible Accesories: Insulated flexible duct (TFTA) and non-insulated flexible duct (TFST); Description: Round diffuser; Fabricant: AIRZONE; Fixing: Security mechanical attachment. Mounting bracket; Installation instructions: http://doc.airzone.es/producto/actuales/AirQ/AirQ_DFCI_A4_EN.pdf; Long Description: Round diffuser DFCI to supply air in 4 directions that enables the air supply. Easy to disassemble to facilitate its maintenance. Designed to be installed in ceiling.; Modèle: DFCI150BC; Nom du type: ø200 mm; Numéro OmniClass: 23.75.70.21.27.11; Product certification: http://doc.airzone.es/BIM/AirQ/Airzone_air_diffusion_Certificates.zip; Product Code: DFCI150BC; Product Comments: Refer to technical documentation for further details; Product Documentation Download URL: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Product url: http://www.airzone.es/en/; Technical description: http://doc.airzone.es/BIM/AirQ/Airzone_DFCI.zip; Titre OmniClass: Diffusers, Registers, and Grilles; Type Image Comments: Image available in product documentation download; URL: www.airzone.es
Type - Matériaux et finitions - Accessories Material: Metal - AIRZONE - Aluminium - Brushed; Main Material: Metal - AIRZONE - Extruded Aluminium - White (RAL 9010); Finish: White (RAL 9010); Material main: Aluminium; Material secondary: Galvanized steel
Type - Génie climatique - Débit - Débit max.: 0.416667 m3/s; Débit min.: 0.0416667 m3/s; Effective Area: 0.014 m2
Type - Pset_AirTerminalTypeCommon - EffectiveArea: 0.014 m2
Type - Pset_ManufacturerTypeInformation - Manufacturer: AIRZONE
Pset_DistributionFlowElementCommon - Reference: ø200 mm; sets with these values: 2
Autre - Famille: AI_Bouche aération_Circulaire Soufflage; Type: ø200 mm; Famille et type: AI_Bouche aération_Circulaire Soufflage: ø200 mm; ID du type: 874897
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2675 mm; Élévation par rapport au niveau: 2675 mm; Hôte: Niveau : RDC
Données - Q: 150
Cotes - Surface: 0.128786 m2; Taille: 200ø; Volume: 0.00300688 m3
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Type de système: 0.Extraction (VMC); Abréviation du système: VMC; Classification du système: Soufflage
Génie climatique - Débit - Débit: 0.0416667 m3/s; Flow: 0.0416667 m3/s; Pressure Drop: 12.469 Pa; Sound Level in dB(A): 13; Throw Distance: 1697 mm; Velocity: 2.97619 m/s
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Bouche aération_Circulaire Soufflage:ø200 mm:...) | Identifiant | Nom du système = Group
1156136 | 65 | VMC 6
1156175 | 67 | VMC 7
1156206 | 69 | VMC 9
1156291 | 73 | VMC 11

# IfcFlowTerminal: AI_Bouche aération_Grille d'air neuf:300x300 Grille de transfert (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Bouche d'aération; Longueur 1: 50 mm; Nom de la famille: AI_Bouche aération_Grille d'air neuf
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Diamètre de la gaine: 250 mm; Epaisseur du panneau: 5 mm; Hauteur de la gaine: 300 mm; Hauteur de la grille: 95 mm; Largeur: 315 mm; Largeur de la gaine: 300 mm; Largeur de la grille: 342 mm; Longueur: 315 mm; Longueur de la grille: 342 mm
Type - Données d'identification - Nom du type: 300x300 Grille de transfert; Sous-projet: Famille : Bouche d'aération : AI_Bouche aération_Grille d'air neuf
Pset_DistributionFlowElementCommon - Reference: 300x300 Grille de transfert; sets with these values: 2
Autre - Famille: AI_Bouche aération_Grille d'air neuf; Famille et type: AI_Bouche aération_Grille d'air neuf: 300x300 Grille de transfert; ID du type: 976362; Type: 300x300 Grille de transfert
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 247.3 mm; Élévation par rapport au niveau: 247.3 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.120384 m2; Taille: 300x300; Volume: 0.00058482 m3
Données d'identification - Sous-projet: 01_CVC; AI_Preneur: SHLMR
Génie climatique - Type de système: VMC; Classification du système: Soufflage
Génie climatique - Débit - Débit: 0.078 m3/s; Débit d'air: 0.025 m3/s; Perte de charge: 7 Pa
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Bouche aération_Grille d'air neuf:300x300 Grille de transfert:...) | Identifiant | Nom du système = Group
976559 | 376 | Génie climatique VMC 1
976625 | 41 | Génie climatique VMC 2

# IfcFlowTerminal: AI_Bouche aération_Grille de soufflage rectangulaire sur gaine:300x150 (10)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Bouche d'aération; Longueur 1: 25 mm; Nom de la famille: AI_Bouche aération_Grille de soufflage rectangulaire sur gaine
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Diamètre de la gaine: 250 mm; Epaisseur du panneau: 5 mm; Hauteur de la gaine: 300 mm; Hauteur de la grille: 111 mm; Largeur: 315 mm; Largeur de la gaine: 150 mm; Largeur de la grille: 342 mm; Longueur: 165 mm; Longueur de la grille: 192 mm
Type - Données d'identification - Nom du type: 300x150; Sous-projet: Famille : Bouche d'aération : AI_Bouche aération_Grille de soufflage rectangulaire sur gaine
Pset_DistributionFlowElementCommon - Reference: 300x150; sets with these values: 2
Autre - Famille: AI_Bouche aération_Grille de soufflage rectangulaire sur gaine; Famille et type: AI_Bouche aération_Grille de soufflage rectangulaire sur gaine: 300x150; ID du type: 885732; Type: 300x150
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - AI_Décalage symbole horizontal: 150 mm; Surface: 0.068334 m2; Taille: 150x300; Volume: 0.00032832 m3
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Type de système: 0.Soufflage; Abréviation du système: S; Classification du système: Soufflage
Génie climatique - Débit - Perte de charge: 9 Pa
Phase de construction - Phase de création: Nouvelle construction
Visibilité - AI_Visibilité Flèche: yes
Name (AI_Bouche aération_Grille de soufflage rectangulaire sur gaine:300x150:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant | Nom du système = Group | Débit (m3/s) = Débit d'air (m3/s)
885989 | 2700 | 14 | S 4 | 0.0416667
886148 | 2620 | 15 | S 4 | 0.0416667
886470 | 2675 | 16 | S 4 | 0.0416667
886602 | 2642.5 | 17 | S 4 | 0.0277778
886753 | 2700 | 18 | S 2 | 0.0277778
886878 | 2750 | 19 | S 2 | 0.0277778
886970 | 2750 | 20 | S 2 | 0.0277778
922859 | 2740.1 | 21 | S 1 | 0.0138889
971989 | 2700 | 38 | S 2 | 0.0277778
1154102 | 2670 | 63 | S 4 | 0.0347222

# IfcFlowTerminal: AI_Bouche aération_Grille de soufflage rectangulaire sur gaine:300x300 grille de transfert (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Bouche d'aération; Longueur 1: 50 mm; Nom de la famille: AI_Bouche aération_Grille de soufflage rectangulaire sur gaine
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Diamètre de la gaine: 250 mm; Epaisseur du panneau: 5 mm; Hauteur de la gaine: 300 mm; Hauteur de la grille: 111 mm; Largeur: 315 mm; Largeur de la gaine: 300 mm; Largeur de la grille: 342 mm; Longueur: 315 mm; Longueur de la grille: 342 mm
Type - Données d'identification - Sous-projet: Famille : Bouche d'aération : AI_Bouche aération_Grille de soufflage rectangulaire sur gaine; Nom du type: 300x300 grille de transfert
Pset_DistributionFlowElementCommon - Reference: 300x300 grille de transfert; sets with these values: 2
Autre - Famille: AI_Bouche aération_Grille de soufflage rectangulaire sur gaine; Famille et type: AI_Bouche aération_Grille de soufflage rectangulaire sur gaine: 300x300 grille de transfert; ID du type: 885734; Type: 300x300 grille de transfert
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 247.3 mm; Élévation par rapport au niveau: 247.3 mm; Hôte: Niveau : RDC
Cotes - Surface: 0.120384 m2; Taille: 300x300; Volume: 0.00058482 m3
Données d'identification - Sous-projet: 01_CVC; AI_Preneur: SHLMR
Génie climatique - Type de système: VMC; Classification du système: Soufflage
Génie climatique - Débit - Débit: 0.0779999 m3/s; Débit d'air: 0.078 m3/s; Perte de charge: 9 Pa
Phase de construction - Phase de création: Nouvelle construction
Visibilité - AI_Visibilité Flèche: yes
Name (AI_Bouche aération_Grille de soufflage rectangulaire sur gaine:300x300 grille de transfert:...) | AI_Décalage symbole horizontal (mm) | Identifiant | Nom du système = Group
976560 | 200 | 383 | Génie climatique VMC 1
976626 | 446.971 | 42 | Génie climatique VMC 2

# IfcFlowTerminal: AI_Disp secu_Détecteur volumétrique:Presence Detector - 70 x 100 x 70 (5)
In: RDC
Type - Material: White Plastic
Type - Autre - Catégorie: Dispositifs de sécurité; Mass: 0.26 kg; Nom de la famille: AI_Disp secu_Détecteur volumétrique
Type - Contraintes - Elévation par défaut: 0 mm; R: 25 mm
Type - Cotes - Maximum Span: 15000 mm; Overall Depth: 70 mm; Overall Height: 100 mm; Overall Width: 70 mm
Type - Electrotechnique - Nominal Voltage: 230 V
Type - Données d'identification - BC_OBJECT_ID: 6136; Commentaires du type: Presence Detector - 70 x 100 x 70; Description: Generic Presence Detector; Modèle: Presence Detector; Nom du type: Presence Detector - 70 x 100 x 70; Numéro OmniClass: 23.85.30.14.14; Sous-projet: Famille : Dispositifs de sécurité : AI_Disp secu_Détecteur volumétrique; Titre OmniClass: Movement/Vibration Detection; URL: www.bimandco.com
Type - Pset_ElectricalDeviceCommon - NominalVoltage: 230 V
Pset_DistributionFlowElementCommon - Reference: Presence Detector - 70 x 100 x 70; sets with these values: 2
Autre - Famille: AI_Disp secu_Détecteur volumétrique; Famille et type: AI_Disp secu_Détecteur volumétrique: Presence Detector - 70 x 100 x 70; ID du type: 1110625; Type: Presence Detector - 70 x 100 x 70
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - Surface: 0.0160416 m2; Volume: 0.000372215 m3
Electricité - Circuit - Données électriques: 0 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Disp secu_Détecteur volumétrique:Presence Detector - 70 x 100 x 70:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant
1195043 | 2600.77 | 2
1195094 | 2600.77 | 3
1195289 | 2600.77 | 4
1195342 | 2600.77 | 5
1197087 | 2685.77 | 6

# IfcFlowTerminal: AI_Dispositif d'éclairage_Détecteur de présence:D (7)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Dispositifs d'éclairage; Nom de la famille: AI_Dispositif d'éclairage_Détecteur de présence
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 50 mm; AI_Rayon Equipement: 60 mm
Type - Données d'identification - Nom du type: D; Numéro OmniClass: 23.80.70.00; Sous-projet: Famille : Dispositifs d'éclairage : AI_Dispositif d'éclairage_Détecteur de présence; Titre OmniClass: Lighting
Pset_DistributionFlowElementCommon - Reference: D; sets with these values: 2
Autre - Famille: AI_Dispositif d'éclairage_Détecteur de présence; Famille et type: AI_Dispositif d'éclairage_Détecteur de présence: D; ID du type: 1110610; Type: D
Contraintes - Niveau: RDC; Hôte: Niveau : RDC
Cotes - Surface: 0.020733 m2; Volume: 0.00056546 m3
Electricité - Circuit - Données électriques: 0 V/1-0 VA
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Dispositif d'éclairage_Détecteur de présence:D:...) | Décalage par rapport à l'hôte (mm) = Élévation par rapport au niveau (mm) | Identifiant
1178914 | 2500 | 1
1178952 | 2500 | 2
1179108 | 2500 | 3
1179197 | 2500 | 4
1179208 | 2500 | 5
1179237 | 2500 | 6
1184911 | 2610 | 7

# IfcFlowTerminal: AI_Eqpmt elec_Armoire électrique LOD400:TGBT 1200 x 450 x 1450, AI_Eqpmt elec_Armoire électrique LOD400:TGBT 1200 x 450 x 1450:889572
In: RDC
Type - Material: Acier, finition peinture, noir, Acier, finition peinture, gris
Type - Autre - Catégorie: Tableaux/Baies; Nom de la famille: AI_Eqpmt elec_Armoire électrique LOD400
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Overall Depth: 450 mm; Overall Height: 1200 mm; Overall Length: 1450 mm
Type - Données d'identification - Description: Generic Control Cabinet; Modèle: Generic Control Cabinet; Nom du type: TGBT 1200 x 450 x 1450; Numéro OmniClass: 23.80.30.11.17; Sous-projet: Famille : Tableaux/Baies : AI_Eqpmt elec_Armoire électrique LOD400; Titre OmniClass: Distribution Boards and Control Panels; URL: www.bimandco.com
Type - Matériaux et finitions - Main Material: Acier, finition peinture, gris
Pset_DistributionFlowElementCommon - Reference: TGBT 1200 x 450 x 1450; sets with these values: 2
Autre - Famille: AI_Eqpmt elec_Armoire électrique LOD400; Famille et type: AI_Eqpmt elec_Armoire électrique LOD400: TGBT 1200 x 450 x 1450; ID du type: 889561; Type: TGBT 1200 x 450 x 1450
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 0 mm; Élévation par rapport au niveau: 0 mm; Hôte: Niveau : RDC
Cotes - Surface: 3.63258 m2; Volume: 0.780744 m3
Electricité - Circuit - Boîtes de raccordement: yes; Cosses d'artère secondaire: yes; Option de numérotation de circuit: Par défaut; Données électriques: 0 V/1-0 VA; Intensité nominale MCB: 1 A
Electricité - Charges - Coefficient d'utilisation global: 1; Puissance apparente des boîtes de raccordement Phase A: 0 W; Puissance apparente des boîtes de raccordement Phase B: 0 W; Puissance apparente des boîtes de raccordement Phase C: 0 W; Puissance apparente du circuit de dérivation Phase A: 0 W; Puissance apparente du circuit de dérivation Phase B: 0 W; Puissance apparente du circuit de dérivation Phase C: 0 W; Puissance apparente - Phase A: 0 W; Puissance apparente - Phase B: 0 W; Puissance apparente - Phase C: 0 W; Puissance installée totale: 0 W; Puissance utilisée totale estimée: 0 W
Données d'identification - Sous-projet: 02_ELE; Identifiant: 4
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowTerminal: AI_Eqpmt elec_Borne véhicule électrique:Borne simple, AI_Eqpmt elec_Borne véhicule électrique:Borne simple:1174640
In: RDC
Type - PredefinedType: POWEROUTLET; Material: Color RGB 0-145-0, Color RGB 69-69-69, Color RGB 255-255-255
Type - Autre - Catégorie: Tableaux/Baies; Nom de la famille: AI_Eqpmt elec_Borne véhicule électrique
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Rotation U-Axis Default Correction: 180 deg; Rotation V-Axis Default Correction: 180 deg; Rotation W-Axis Default Correction: 180 deg
Type - Electrotechnique - Phases: 1; Voltage_x: 230 V
Type - Electricité - Charges - Power: 3 W
Type - Données d'identification - Custom: no; App ID: EL_MODELPARTSYSTEM_MC; Article Description: Electrical charger for electric cars; Article Type: Charger FloorStanding; Category: EL_POWERCONSUMER; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Description: Electrical charger for electric cars; EMCS Version: 2.0; ETIM Article Class: EC002883; Fabricant: Unspecified; Family Version: 11.14; MEPcontent Class: CHARGING_STATION; Modèle: Charger FloorStanding; Nom du type: Borne simple; Product Line: Unspecified; Revit Version: 2018; Sous-projet: Famille : Tableaux/Baies : AI_Eqpmt elec_Borne véhicule électrique; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Matériaux et finitions - Body: Color RGB 255-255-255; Charger: Color RGB 0-145-0; Pole: Color RGB 69-69-69
