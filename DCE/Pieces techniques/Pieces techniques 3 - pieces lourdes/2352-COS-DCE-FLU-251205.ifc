Properties of the parts of a building model (IFC2X3), part 6 of 8

# IfcFlowSegment: Canalisation:PVC (114)
Name (Canalisation:PVC:...) | Length (mm) = Longueur (mm) | Niveau de référence | Arase inférieure à son extrémité amont (mm) = Arase inférieure avec isolant à son extrémité amont (mm) | Arase inférieure à son extrémité aval (mm) = Arase inférieure avec isolant à son extrémité aval (mm) | Arase supérieure à son extrémité amont (mm) = Arase supérieure avec isolant à son extrémité amont (mm) | Arase supérieure à son extrémité aval (mm) = Arase supérieure avec isolant à son extrémité aval (mm) | Élévation centrale de départ (mm) = Elévation du milieu (mm) | Élévation centrale de fin (mm) | Elévation de l'axe à son extrémité amont (mm) | Elévation de l'axe à son extrémité aval (mm) | Elévation du fond (fil d'eau) à son extrémité amont (mm) | Elévation du fond (fil d'eau) à son extrémité aval (mm) | Elévation du point haut intérieur du tube à son extrémité amont (mm) | Elévation du point haut intérieur du tube à son extrémité aval (mm) | Inclinaison | Diamètre extérieur (mm) = Diamètre (mm) | Diamètre intérieur (mm) | Epaisseur de paroi (mm) | Taille = Taille globale | Sous-projet | Abréviation du système | Elévation du fond (fil d'eau) (mm) | Nom du système | Surface (m2) | Type de système | Tronçon | Rugosité relative | Group
1222649 | 1425.01 | RDC | -276.694 | -290.944 | -244.696 | -258.945 | -260.695 | -274.944 | -260.695 | -274.944 | -273.694 | -287.944 | -247.696 | -261.945 | 0.01 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -287.944 | EU 11 | 0.143258 | 3.Eaux Usées | 9 | 0.0000976923 | EU 11
1222651 | 953.216 | RDC | 741.001 | -212.215 | 741.001 | -212.215 | 741.001 | -212.215 | 741.001 | -212.215 | 741.001 | -212.215 | 741.001 | -212.215 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -212.215 | EU 11 | 0.0958277 | 3.Eaux Usées | 9 | 0.0000976923 | EU 11
1222706 | 131.263 | RDC | -323.424 | -454.687 | -323.424 | -454.687 | -454.687 | -323.424 | -323.424 | -454.687 | -323.424 | -454.687 | -323.424 | -454.687 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -454.687 | EU 11 | 0.013196 | 3.Eaux Usées | 9 | 0.0000976923 | EU 11
1222709 | 2759.5 | R-1 | 2300.68 | 2273.08 | 2400.67 | 2373.08 | 2350.68 | 2323.08 | 2350.68 | 2323.08 | 2303.68 | 2276.08 | 2397.67 | 2370.08 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -623.915 | U 2 | 0.866922 | 3.Unitaire | 17 | 0.0000270213 | U 2
1223405 | 333.726 | RDC | 777.348 | 443.621 | 777.348 | 443.622 | 443.622 | 777.348 | 777.348 | 443.622 | 777.348 | 443.622 | 777.348 | 443.622 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | 443.622 | EU 19 | 0.0335498 | 3.Eaux Usées | 11 | 0.0000976923 | EU 19
1223475 | 111.159 | RDC | 379.623 | 379.622 | 411.623 | 411.622 | 395.623 | 395.622 | 395.623 | 395.622 | 382.623 | 382.622 | 408.623 | 408.622 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | 382.622 | EU 19 | 0.011175 | 3.Eaux Usées | 11 | 0.0000976923 | EU 19
1223499 | 544.934 | RDC | 339.359 | -205.575 | 339.359 | -205.575 | -205.575 | 339.359 | 339.359 | -205.575 | 339.359 | -205.575 | 339.359 | -205.575 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -205.575 | EU 19 | 0.0547827 | 3.Eaux Usées | 9 | 0.0000976923 | EU 19
1223591 | 39.5 | R-1 | 2458.42 | 2458.42 | 2558.42 | 2558.42 | 2508.42 | 2508.42 | 2508.42 | 2508.42 | 2461.42 | 2461.42 | 2555.42 | 2555.42 |  | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -438.582 | U 2 | 0.0124093 | 3.Unitaire | 12 | 0.0000270213 | U 2
1223858 | 156.545 | R-1 | 2257.48 | 2226.83 | 2355.55 | 2324.9 | 2306.52 | 2275.87 | 2306.52 | 2275.87 | 2260.43 | 2229.78 | 2352.61 | 2321.96 | 0.199658 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -670.225 | U 2 | 0.0491802 | 3.Unitaire | 17 | 0.0000270213 | EU 2; U 2
1223920 | 7057.63 | R-1 | 2161.05 | 2055.19 | 2261.03 | 2155.18 | 2105.19 | 2211.04 | 2211.04 | 2105.19 | 2164.04 | 2058.19 | 2258.03 | 2152.18 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -841.808 | EU 2 | 2.21722 | 3.Eaux Usées | 32 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
1223987 | 63.6591 | R-1 | 2250.88 | 2232.53 | 2346.63 | 2328.29 | 2298.75 | 2280.41 | 2298.75 | 2280.41 | 2253.75 | 2235.4 | 2343.76 | 2325.42 | 0.300917 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -664.595 | U 1 | 0.0199991 | 3.Unitaire | 15 | 0.0000270213 | U 1
1224057 | 549.327 | R-1 | 2172.98 | 2164.74 | 2272.97 | 2264.73 | 2214.73 | 2222.97 | 2222.97 | 2214.73 | 2175.98 | 2167.74 | 2269.97 | 2261.73 | 0.015 | 100 | 94 | 3 | 100 mmø | 03_PLB | EU | -732.26 | EU 2 | 0.172576 | 3.Eaux Usées | 27 | 0.0000270213 | EU 2 | Données d'identification - AI_Phase: EXISTANT
1226859 | 2418.75 | RDC | -281.099 | -305.286 | -249.101 | -273.287 | -265.1 | -289.286 | -265.1 | -289.286 | -278.1 | -302.286 | -252.101 | -276.287 | 0.01 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -302.286 | EU 16 | 0.243159 | 3.Eaux Usées | 8 | 0.0000976923 | EU 16
1226861 | 758.572 | RDC | 541.952 | -216.62 | 541.952 | -216.62 | 541.952 | -216.62 | 541.952 | -216.62 | 541.952 | -216.62 | 541.952 | -216.62 |  | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -216.62 | EU 16 | 0.07626 | 3.Eaux Usées | 8 | 0.0000976923 | EU 16
1226874 | 105.921 | RDC | -321.864 | -380.914 | -295.298 | -354.348 | -367.631 | -308.581 | -308.581 | -367.631 | -319.374 | -378.424 | -297.789 | -356.839 | 0.671534 | 32 | 26 | 3 | 32 mmø | 03_PLB | EU | -378.424 | EU 16 | 0.0106483 | 3.Eaux Usées | 8 | 0.0000976923 | EU 16
1226898 | 505.29 | R-1 | 2436.81 | 2431.75 | 2536.8 | 2531.75 | 2486.81 | 2481.75 | 2486.81 | 2481.75 | 2439.81 | 2434.75 | 2533.8 | 2528.75 | 0.01 | 100 | 94 | 3 | 100 mmø | 03_PLB | U | -465.245 | U 2 | 0.158741 | 3.Unitaire | 19 | 0.0000270213 | U 2

# IfcFlowSegment: Canalisation:PVC Pression HTA (65)
In: RDC
Type - Autre - Catégorie: Canalisation; Nom de la famille: Canalisation
Type - Données d'identification - Sous-projet: Canalisation; Nom du type: PVC Pression HTA
Pset_DistributionFlowElementCommon - Reference: PVC Pression HTA; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Autre - Famille: Canalisation; Famille et type: Canalisation: PVC Pression HTA; ID du type: 804577; Type: PVC Pression HTA
Contraintes - Justification horizontale: Centre; Justification verticale: Milieu
Données d'identification - Sous-projet: 03_PLB
Génie climatique - Nomenclature/type: Nomenclature 40; Type de système: 2.Eau Froide Sanitaire; Abréviation du système: EF; Classification du système: Eau froide sanitaire; Matériau: HTA_Girpi; Rugosité: 0.00254 mm; Segment de canalisation: HTA_Girpi - Nomenclature 40; Type de connexion: Générique
Génie climatique - Débit - Etat du flux: Laminaire; Facteur de frottement: 0; Frottement: 0; Nombre de Reynolds: 0; Débit par appareil: 0; Débit: 0 m3/s; Débit supplémentaire: 0 m3/s; Perte de pression: 0 Pa; Pression dynamique: 0 Pa; Vitesse: 0 m/s
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Name (Canalisation:PVC Pression HTA:...) | Length (mm) = Longueur (mm) | Niveau de référence | Arase inférieure à son extrémité amont (mm) = Arase inférieure avec isolant à son extrémité amont (mm) | Arase inférieure à son extrémité aval (mm) = Arase inférieure avec isolant à son extrémité aval (mm) | Arase supérieure à son extrémité amont (mm) = Arase supérieure avec isolant à son extrémité amont (mm) | Arase supérieure à son extrémité aval (mm) = Arase supérieure avec isolant à son extrémité aval (mm) | Élévation centrale de départ (mm) = Elévation du milieu (mm) | Élévation centrale de fin (mm) | Elévation de l'axe à son extrémité amont (mm) | Elévation de l'axe à son extrémité aval (mm) | Elévation du fond (fil d'eau) à son extrémité amont (mm) | Elévation du fond (fil d'eau) à son extrémité aval (mm) | Elévation du point haut intérieur du tube à son extrémité amont (mm) | Elévation du point haut intérieur du tube à son extrémité aval (mm) | Diamètre extérieur (mm) | Diamètre intérieur (mm) | Epaisseur de paroi (mm) | Taille = Taille globale | Diamètre (mm) | Elévation du fond (fil d'eau) (mm) | Nom du système = Group | Surface (m2) | Rugosité relative | Tronçon
948278 | 2242.18 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 1 | 0.140881 | 0.000121357 | 50
948282 | 2348.07 | RDC | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 350.108 | EF 1 | 0.147534 | 0.000121357 | 50
948292 | 2348.07 | RDC | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 350.108 | EF 1 | 0.147534 | 0.000121357 | 47
948296 | 4140.78 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 1 | 0.260173 | 0.000121357 | 47
948298 | 2441.96 | RDC | 2698.18 | 256.22 | 2698.18 | 256.22 | 2698.18 | 256.22 | 2698.18 | 256.22 | 2698.18 | 256.22 | 2698.18 | 256.22 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 256.22 | EF 1 | 0.153433 | 0.000121357 | 47
948300 | 237.85 | RDC | 223.973 | 223.973 | 250.643 | 250.643 | 237.308 | 237.308 | 237.308 | 237.308 | 226.843 | 226.843 | 247.773 | 247.773 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 226.843 | EF 1 | 0.0149446 | 0.000121357 | 47
948302 | 136.979 | RDC | 224.004 | 223.972 | 250.674 | 250.642 | 237.307 | 237.339 | 237.339 | 237.307 | 226.874 | 226.842 | 247.804 | 247.772 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 226.842 | EF 1 | 0.00860665 | 0.000121357 | 47 | Contraintes - Inclinaison: 0.000232782
948318 | 580.107 | RDC | 308.408 | -271.7 | 308.408 | -271.699 | -271.7 | 308.408 | 308.408 | -271.7 | 308.408 | -271.7 | 308.408 | -271.699 | 33.401 | 26.645 | 3.378 | 25 mmø | 25 | -271.7 | EF 1 | 0.0455615 | 0.0000953275 | 114
948326 | 312.616 | RDC | 316.707 | 316.707 | 350.108 | 350.108 | 333.408 | 333.408 | 333.408 | 333.408 | 320.085 | 320.085 | 346.73 | 346.73 | 33.401 | 26.645 | 3.378 | 25 mmø | 25 | 320.085 | EF 1 | 0.0245528 | 0.0000953275 | 102
948339 | 2233.07 | RDC | 2583.18 | 350.108 | 2583.18 | 350.108 | 2583.18 | 350.108 | 2583.18 | 350.108 | 2583.18 | 350.108 | 2583.18 | 350.108 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 350.108 | EF 1 | 0.140308 | 0.000121357 | 95
948359 | 164.388 | RDC | 514.496 | 350.108 | 514.496 | 350.108 | 514.496 | 350.108 | 514.496 | 350.108 | 514.496 | 350.108 | 514.496 | 350.108 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 350.108 | EF 1 | 0.0103288 | 0.000121357 | 85
948390 | 46.1286 | RDC | 1200.02 | 1153.89 | 1200.02 | 1153.89 | 1200.02 | 1153.89 | 1200.02 | 1153.89 | 1200.02 | 1153.89 | 1200.02 | 1153.89 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 1153.89 | EF 1 | 0.00289834 | 0.000121357 | 29
948392 | 71.8846 | RDC | 1121.64 | 1121.64 | 1148.31 | 1148.31 | 1134.98 | 1134.98 | 1134.98 | 1134.98 | 1124.51 | 1124.51 | 1145.44 | 1145.44 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 1124.51 | EF 1 | 0.00451664 | 0.000121357 | 29
948394 | 1544.29 | RDC | 2698.18 | 1153.89 | 2698.18 | 1153.89 | 1153.89 | 2698.18 | 2698.18 | 1153.89 | 2698.18 | 1153.89 | 2698.18 | 1153.89 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 1153.89 | EF 1 | 0.0970304 | 0.000121357 | 29
948396 | 917.14 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 1 | 0.0576256 | 0.000121357 | 29
948411 | 1456.18 | RDC | 2698.18 | 1242 | 2698.18 | 1242 | 1242 | 2698.18 | 2698.18 | 1242 | 2698.18 | 1242 | 2698.18 | 1242 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 1242 | EF 1 | 0.0914943 | 0.000121357 | 51
948413 | 447.71 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 1 | 0.0281305 | 0.000121357 | 51
948415 | 636.594 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 1 | 0.0399984 | 0.000121357 | 51
948417 | 1195.03 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 1 | 0.0750858 | 0.000121357 | 51
948427 | 95.4339 | RDC | 361.737 | 266.303 | 361.737 | 266.303 | 361.737 | 266.303 | 361.737 | 266.303 | 361.737 | 266.303 | 361.737 | 266.303 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 266.303 | EF 1 | 0.00599629 | 0.000121357 | 35
948432 | 621.088 | RDC | 877.303 | 256.215 | 877.303 | 256.215 | 877.303 | 256.215 | 877.303 | 256.215 | 877.303 | 256.215 | 877.303 | 256.215 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 256.215 | EF 1 | 0.0390241 | 0.000121357 | 48
948434 | 838.341 | RDC | 224.002 | 223.968 | 250.672 | 250.638 | 237.303 | 237.337 | 237.337 | 237.303 | 226.872 | 226.838 | 247.802 | 247.768 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 226.838 | EF 1 | 0.0526745 | 0.000121357 | 48 | Contraintes - Inclinaison: 0.0000399714
948482 | 2317.57 | RDC | 2588.75 | 2588.75 | 2615.42 | 2615.42 | 2602.09 | 2602.09 | 2602.09 | 2602.09 | 2591.62 | 2591.62 | 2612.55 | 2612.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2591.62 | EF 1 | 0.145617 | 0.000121357 | 95
948577 | 46.1286 | RDC | 1200.02 | 1153.89 | 1200.02 | 1153.89 | 1200.02 | 1153.89 | 1200.02 | 1153.89 | 1200.02 | 1153.89 | 1200.02 | 1153.89 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 1153.89 | EF 1 | 0.00289834 | 0.000121357 | 72
948579 | 71.885 | RDC | 1121.64 | 1121.64 | 1148.31 | 1148.31 | 1134.98 | 1134.98 | 1134.98 | 1134.98 | 1124.51 | 1124.51 | 1145.44 | 1145.44 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 1124.51 | EF 1 | 0.00451667 | 0.000121357 | 72
948581 | 1429.29 | RDC | 2583.18 | 1153.89 | 2583.18 | 1153.89 | 1153.89 | 2583.18 | 2583.18 | 1153.89 | 2583.18 | 1153.89 | 2583.18 | 1153.89 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 1153.89 | EF 1 | 0.0898047 | 0.000121357 | 72
948583 | 1037.24 | RDC | 2588.75 | 2588.75 | 2615.42 | 2615.42 | 2602.09 | 2602.09 | 2602.09 | 2602.09 | 2591.62 | 2591.62 | 2612.55 | 2612.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2591.62 | EF 1 | 0.0651718 | 0.000121357 | 72
948598 | 1366.09 | RDC | 2583.18 | 1217.09 | 2583.18 | 1217.09 | 2583.18 | 1217.09 | 2583.18 | 1217.09 | 2583.18 | 1217.09 | 2583.18 | 1217.09 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 1217.09 | EF 1 | 0.0858339 | 0.000121357 | 71
948600 | 182.292 | RDC | 2588.75 | 2588.75 | 2615.42 | 2615.42 | 2602.09 | 2602.09 | 2602.09 | 2602.09 | 2591.62 | 2591.62 | 2612.55 | 2612.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2591.62 | EF 1 | 0.0114538 | 0.000121357 | 71
948602 | 604.293 | RDC | 2588.75 | 2588.75 | 2615.42 | 2615.42 | 2602.09 | 2602.09 | 2602.09 | 2602.09 | 2591.62 | 2591.62 | 2612.55 | 2612.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2591.62 | EF 1 | 0.0379689 | 0.000121357 | 71
948604 | 1246.9 | RDC | 2588.75 | 2588.75 | 2615.42 | 2615.42 | 2602.09 | 2602.09 | 2602.09 | 2602.09 | 2591.62 | 2591.62 | 2612.55 | 2612.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2591.62 | EF 1 | 0.0783452 | 0.000121357 | 71
948620 | 38.6487 | RDC | 537.365 | 537.359 | 564.035 | 564.029 | 550.694 | 550.7 | 550.7 | 550.694 | 540.235 | 540.229 | 561.165 | 561.159 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 540.229 | EF 1 | 0.00242837 | 0.000121357 | 2
948662 | 4457.97 | R-1 | 2344.02 | 2344.02 | 2377.42 | 2377.42 | 2360.72 | 2360.72 | 2360.72 | 2360.72 | 2347.4 | 2347.4 | 2374.05 | 2374.05 | 33.401 | 26.645 | 3.378 | 25 mmø | 25 | -552.599 | EF 1 | 0.350128 | 0.0000953275 | 114
948671 | 13770.8 | R-1 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | 33.401 | 26.645 | 3.378 | 25 mmø | 25 | -310.022 | EF 1 | 1.08156 | 0.0000953275 | 114
948697 | 275.458 | R-1 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | 33.401 | 26.645 | 3.378 | 25 mmø | 25 | -310.022 | EF 1 | 0.0216344 | 0.0000953275 | 114
948874 | 2335.72 | R-1 | 2335.72 | 0 | 2335.72 | 0 | 2335.72 | 0 | 2335.72 | 0 | 2335.72 | 0 | 2335.72 | 0 | 33.401 | 26.645 | 3.378 | 25 mmø | 25 | -2900 | EF 1 | 0.183447 | 0.0000953275 | 114
1215114 | 501.606 | RDC | 316.707 | 316.707 | 350.108 | 350.108 | 333.408 | 333.408 | 333.408 | 333.408 | 320.085 | 320.085 | 346.73 | 346.73 | 33.401 | 26.645 | 3.378 | 25 mmø | 25 | 320.085 | EF 1 | 0.039396 | 0.0000953275 | 114
1215133 | 1921.09 | RDC | 520.073 | 520.073 | 546.743 | 546.743 | 533.408 | 533.408 | 533.408 | 533.408 | 522.943 | 522.943 | 543.873 | 543.873 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 522.943 | EF 1 | 0.120706 | 0.000121357 | 85
1215240 | 220.398 | RDC | 537.359 | 537.359 | 564.029 | 564.029 | 550.694 | 550.694 | 550.694 | 550.694 | 540.229 | 540.229 | 561.159 | 561.159 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 540.229 | EF 1 | 0.013848 | 0.000121357 | 98
1215277 | 44.4947 | RDC | 537.359 | 537.359 | 564.029 | 564.029 | 550.694 | 550.694 | 550.694 | 550.694 | 540.229 | 540.229 | 561.159 | 561.159 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 540.229 | EF 1 | 0.00279568 | 0.000121357 | 106
1215300 | 181.674 | RDC | 531.782 | 350.108 | 531.782 | 350.108 | 531.782 | 350.108 | 531.782 | 350.108 | 531.782 | 350.108 | 531.782 | 350.108 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 350.108 | EF 1 | 0.0114149 | 0.000121357 | 100
1215311 | 267.543 | RDC | 537.359 | 537.359 | 564.029 | 564.029 | 550.694 | 550.694 | 550.694 | 550.694 | 540.229 | 540.229 | 561.159 | 561.159 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 540.229 | EF 1 | 0.0168102 | 0.000121357 | 100
1215605 | 244.117 | RDC | 537.367 | 537.365 | 564.037 | 564.035 | 550.702 | 550.7 | 550.702 | 550.7 | 540.237 | 540.235 | 561.167 | 561.165 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 540.235 | EF 1 | 0.0153383 | 0.000121357 | 2
1215678 | 999.799 | RDC | 537.365 | 537.365 | 564.035 | 564.035 | 550.7 | 550.7 | 550.7 | 550.7 | 540.235 | 540.235 | 561.165 | 561.165 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 540.235 | EF 1 | 0.0628192 | 0.000121357 | 99
1215685 | 1121.09 | RDC | 537.365 | 537.365 | 564.035 | 564.035 | 550.7 | 550.7 | 550.7 | 550.7 | 540.235 | 540.235 | 561.165 | 561.165 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 540.235 | EF 1 | 0.0704401 | 0.000121357 | 107
1215708 | 323.25 | RDC | 537.365 | 537.357 | 564.035 | 564.027 | 550.7 | 550.692 | 550.7 | 550.692 | 540.235 | 540.227 | 561.165 | 561.157 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 540.227 | EF 1 | 0.0203104 | 0.000121357 | 99
1215833 | 61.1174 | RDC | 439.669 | 378.551 | 439.669 | 378.551 | 378.551 | 439.669 | 439.669 | 378.551 | 439.669 | 378.551 | 439.669 | 378.551 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 378.551 | EF 1 | 0.00384012 | 0.000121357 | 99
1215945 | 329.656 | RDC | 445.245 | 445.245 | 471.915 | 471.915 | 458.58 | 458.58 | 458.58 | 458.58 | 448.115 | 448.115 | 469.045 | 469.045 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 448.115 | EF 1 | 0.0207129 | 0.000121357 | 99
1215990 | 54.2873 | RDC | 531.779 | 477.492 | 531.78 | 477.493 | 531.779 | 477.492 | 531.779 | 477.492 | 531.779 | 477.492 | 531.78 | 477.493 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 477.492 | EF 1 | 0.00341097 | 0.000121357 | 99
1216114 | 132.177 | RDC | 537.364 | 537.36 | 564.034 | 564.03 | 550.699 | 550.695 | 550.699 | 550.695 | 540.234 | 540.23 | 561.164 | 561.16 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 540.23 | EF 1 | 0.0083049 | 0.000121357 | 107
1216125 | 875.569 | RDC | 537.359 | 537.359 | 564.029 | 564.029 | 550.694 | 550.694 | 550.694 | 550.694 | 540.229 | 540.229 | 561.159 | 561.159 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 540.229 | EF 1 | 0.0550136 | 0.000121357 | 107
1222838 | 882.094 | R-1 | 2586.6 | 2586.6 | 2620 | 2620 | 2603.3 | 2603.3 | 2603.3 | 2603.3 | 2589.98 | 2589.98 | 2616.62 | 2616.62 | 33.401 | 26.645 | 3.378 | 25 mmø | 25 | -310.022 | EF 1 | 0.0692795 | 0.0000953275 | 114
1225241 | 2005.49 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 1 | 0.126009 | 0.000121357 | 1
1225269 | 2170.19 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 1 | 0.136357 | 0.000121357 | 119
1225282 | 506.088 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 1 | 0.0317985 | 0.000121357 | 119
1225347 | 747.177 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 1 | 0.0469465 | 0.000121357 | 1
1225355 | 1802.18 | RDC | 2698.18 | 896.001 | 2698.18 | 896.001 | 2698.18 | 896.001 | 2698.18 | 896.001 | 2698.18 | 896.001 | 2698.18 | 896.001 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 896.001 | EF 1 | 0.113234 | 0.000121357 | 1
1225365 | 221.088 | RDC | 863.754 | 863.754 | 890.424 | 890.424 | 877.089 | 877.089 | 877.089 | 877.089 | 866.624 | 866.624 | 887.554 | 887.554 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 866.624 | EF 1 | 0.0138914 | 0.000121357 | 1
1225399 | 2348.07 | RDC | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 350.108 | EF 1 | 0.147534 | 0.000121357 | 1
1225503 | 2348.07 | RDC | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 350.108 | EF 1 | 0.147534 | 0.000121357 | 119
1226707 | 2348.07 | RDC | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 2698.18 | 350.108 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 350.108 | EF 3 | 0.147534 | 0.000121357 | 47
1226709 | 2742.18 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 3 | 0.172296 | 0.000121357 | 47
1226744 | 2587.74 | RDC | 2703.75 | 2703.75 | 2730.42 | 2730.42 | 2717.09 | 2717.09 | 2717.09 | 2717.09 | 2706.62 | 2706.62 | 2727.55 | 2727.55 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 2706.62 | EF 3 | 0.162592 | 0.000121357 | 47
1226780 | 1961.09 | RDC | 2698.18 | 737.089 | 2698.18 | 737.089 | 2698.18 | 737.089 | 2698.18 | 737.089 | 2698.18 | 737.089 | 2698.18 | 737.089 | 26.67 | 20.93 | 2.87 | 20 mmø | 20 | 737.089 | EF 3 | 0.123219 | 0.000121357 | 47
1228273 | 192.577 | R-1 | 2578.3 | 2385.72 | 2578.3 | 2385.72 | 2385.72 | 2578.3 | 2578.3 | 2385.72 | 2578.3 | 2385.72 | 2578.3 | 2385.72 | 33.401 | 26.645 | 3.378 | 25 mmø | 25 | -514.277 | EF 1 | 0.015125 | 0.0000953275 | 114

# IfcFlowSegment: Chemin de câbles avec raccords:Par défaut (94)
In: RDC
Type - PredefinedType: CABLETRAYSEGMENT
Type - Autre - Catégorie: Chemins de câbles; Nom de la famille: Chemin de câbles avec raccords
Type - Electrique - Multiplicateur de rayon de courbure: 1
Type - Données d'identification - Nom du type: Par défaut; Sous-projet: Types de chemins de câbles
Type - Raccords - Courbure horizontale: AI_Raccord cdc_Coude horizontal rayon court: standaard; Courbure verticale extérieure: AI_Raccord cdc_Coude desencdant: standaard; Courbure verticale intérieure: AI_Raccord cdc_Coude montant: standaard; Croix: AI_Raccord cdc_Croix: Standard; Té: AI_Raccord cdc_Té: 150mm Radius; Transition: magi_ch_cable_réduit_court_001: standaard; Union: Chemin de câbles - Union: Standard
Pset_DistributionFlowElementCommon - Reference: Par défaut; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Autre - Famille: Chemin de câbles avec raccords; Famille et type: Chemin de câbles avec raccords: Par défaut; ID du type: 472394; Type: Par défaut
Contraintes - Justification horizontale: Centre; Justification verticale: Milieu
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (Chemin de câbles avec raccords:Par défaut:...) | Length (mm) | Niveau de référence | Arase inférieure à son extrémité amont (mm) | Arase inférieure à son extrémité aval (mm) | Arase supérieure à son extrémité amont (mm) | Arase supérieure à son extrémité aval (mm) | Élévation centrale de départ (mm) = Elévation du milieu (mm) | Élévation centrale de fin (mm) | Elévation de l'axe à son extrémité amont (mm) | Elévation de l'axe à son extrémité aval (mm) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | Taille | Type de service
861421 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 183.671 | 200 mmx60 mmø | cfa
861461 | 60 | RDC | 2673.71 | 2673.71 | 2733.71 | 2733.71 | 2703.71 | 2703.71 | 2703.71 | 2703.71 | 60 | 200 | 507.478 | 200 mmx60 mmø | CF
861471 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 8780 | 200 mmx60 mmø | CF
861474 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 2664.77 | 200 mmx60 mmø | CF
863035 | 60 | RDC | 2440 | 2440 | 2500 | 2500 | 2470 | 2470 | 2470 | 2470 | 60 | 200 | 3550.86 | 200 mmx60 mmø | CF
863055 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 2608.53 | 200 mmx60 mmø | cfa
863281 | 200 | RDC | 2826 | 2732.43 | 2868.42 | 2774.86 | 2847.21 | 2753.65 | 2847.21 | 2753.65 | 60 | 200 | 132.319 | 200 mmx60 mmø | cfa
863293 | 60 | RDC | 2713.86 | 2713.86 | 2773.86 | 2773.86 | 2743.86 | 2743.86 | 2743.86 | 2743.86 | 60 | 200 | 209.189 | 200 mmx60 mmø | cfa
863307 | 200 | RDC | 2826 | 2732.43 | 2868.42 | 2774.86 | 2753.65 | 2847.21 | 2847.21 | 2753.65 | 60 | 200 | 132.319 | 200 mmx60 mmø | cfa
863326 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 255.123 | 200 mmx60 mmø | cfa
863371 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 1264.76 | 200 mmx60 mmø | cfa
905683 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 5156.64 | 200 mmx60 mmø | CF
905785 | 60 | RDC | 2591.39 | 2591.39 | 2651.39 | 2651.39 | 2621.39 | 2621.39 | 2621.39 | 2621.39 | 60 | 200 | 326.583 | 200 mmx60 mmø | cfa
905823 | 60 | RDC | 2591.39 | 2591.39 | 2651.39 | 2651.39 | 2621.39 | 2621.39 | 2621.39 | 2621.39 | 60 | 200 | 326.583 | 200 mmx60 mmø | CF
905824 | 305.516 | RDC | 2826 | 2609.96 | 2868.42 | 2652.39 | 2631.18 | 2847.21 | 2847.21 | 2631.18 | 60 | 200 | 305.516 | 200 mmx60 mmø | CF
905850 | 305.516 | RDC | 2826 | 2609.96 | 2868.42 | 2652.39 | 2631.18 | 2847.21 | 2847.21 | 2631.18 | 60 | 200 | 305.516 | 200 mmx60 mmø | cfa
905892 | 305.516 | RDC | 2826 | 2609.96 | 2868.42 | 2652.39 | 2631.18 | 2847.21 | 2847.21 | 2631.18 | 60 | 200 | 305.516 | 200 mmx60 mmø | CF
905895 | 305.516 | RDC | 2826 | 2609.96 | 2868.42 | 2652.39 | 2631.18 | 2847.21 | 2847.21 | 2631.18 | 60 | 200 | 305.516 | 200 mmx60 mmø | cfa
905909 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 1171.41 | 200 mmx60 mmø | cfa
905932 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 1171.41 | 200 mmx60 mmø | CF
906122 | 60 | RDC | 2673.71 | 2673.71 | 2733.71 | 2733.71 | 2703.71 | 2703.71 | 2703.71 | 2703.71 | 60 | 200 | 87.4351 | 200 mmx60 mmø | CF
906154 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 2111.45 | 200 mmx60 mmø | cfa
906273 | 60 | RDC | 2673.71 | 2673.71 | 2733.71 | 2733.71 | 2703.71 | 2703.71 | 2703.71 | 2703.71 | 60 | 200 | 450.511 | 200 mmx60 mmø | cfa
906317 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 3259.81 | 200 mmx60 mmø | CF
906396 | 60 | RDC | 2673.71 | 2673.71 | 2733.71 | 2733.71 | 2703.71 | 2703.71 | 2703.71 | 2703.71 | 60 | 200 | 83.7862 | 200 mmx60 mmø | cfa
906397 | 200 | RDC | 2826 | 2692.29 | 2868.42 | 2734.71 | 2713.5 | 2847.21 | 2847.21 | 2713.5 | 60 | 200 | 189.097 | 200 mmx60 mmø | cfa
906423 | 200 | RDC | 2826 | 2692.29 | 2868.42 | 2734.71 | 2713.5 | 2847.21 | 2847.21 | 2713.5 | 60 | 200 | 189.097 | 200 mmx60 mmø | CF
906449 | 200 | RDC | 2826 | 2692.29 | 2868.42 | 2734.71 | 2847.21 | 2713.5 | 2847.21 | 2713.5 | 60 | 200 | 189.097 | 200 mmx60 mmø | CF
906479 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 3338.86 | 200 mmx60 mmø | cfa
906480 | 200 | RDC | 2826 | 2692.29 | 2868.42 | 2734.71 | 2847.21 | 2713.5 | 2847.21 | 2713.5 | 60 | 200 | 189.097 | 200 mmx60 mmø | cfa
906679 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 2861.88 | 200 mmx60 mmø | CF
906680 | 519.615 | RDC | 2826 | 2458.57 | 2868.42 | 2501 | 2847.21 | 2479.79 | 2847.21 | 2479.79 | 60 | 200 | 519.615 | 200 mmx60 mmø | CF
906699 | 1139 | RDC | 2339 | 1200 | 2339 | 1200 | 2339 | 1200 | 2339 | 1200 | 60 | 200 | 1139 | 200 mmx60 mmø | CF
924194 | 1226 | RDC | 2726 | 1500 | 2726 | 1500 | 2726 | 1500 | 2726 | 1500 | 60 | 200 | 1226 | 200 mmx60 mmø | cfa
925794 | 60 | RDC | 2440 | 2440 | 2500 | 2500 | 2470 | 2470 | 2470 | 2470 | 60 | 200 | 411.531 | 200 mmx60 mmø | CF
925809 | 60 | RDC | 2440 | 2440 | 2500 | 2500 | 2470 | 2470 | 2470 | 2470 | 60 | 200 | 228 | 200 mmx60 mmø | CF
978008 | 100 | R-1 | 2467.76 | 2467.76 | 2567.76 | 2567.76 | 2517.76 | 2517.76 | 2517.76 | 2517.76 | 100 | 300 | 5049 | 300 mmx100 mmø | CF | Données d'identification - AI_Phase: EXISTANT
978031 | 100 | R-1 | 2467.76 | 2467.76 | 2567.76 | 2567.76 | 2517.76 | 2517.76 | 2517.76 | 2517.76 | 100 | 300 | 5049 | 300 mmx100 mmø | CF | Données d'identification - AI_Phase: EXISTANT
978116 | 141.24 | R-1 | 2810 | 2668.76 | 2810 | 2668.76 | 2668.76 | 2810 | 2810 | 2668.76 | 100 | 300 | 141.24 | 300 mmx100 mmø | CF | Données d'identification - AI_Phase: EXISTANT
978218 | 141.24 | R-1 | 2810 | 2668.76 | 2810 | 2668.76 | 2668.76 | 2810 | 2810 | 2668.76 | 100 | 300 | 141.24 | 300 mmx100 mmø | CF | Données d'identification - AI_Phase: EXISTANT
1156579 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 691.072 | 100 mmx60 mmø | cfa
1156591 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 14358.1 | 200 mmx60 mmø | cfa
1156687 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 786.268 | 100 mmx60 mmø | CF
1156730 | 100 | RDC | 2826 | 2732.43 | 2868.42 | 2774.86 | 2847.21 | 2753.65 | 2847.21 | 2753.65 | 60 | 100 | 132.319 | 100 mmx60 mmø | CF
1156746 | 60 | RDC | 2713.86 | 2713.86 | 2773.86 | 2773.86 | 2743.86 | 2743.86 | 2743.86 | 2743.86 | 60 | 100 | 204.864 | 100 mmx60 mmø | CF
1156760 | 100 | RDC | 2826 | 2732.43 | 2868.42 | 2774.86 | 2753.65 | 2847.21 | 2847.21 | 2753.65 | 60 | 100 | 132.319 | 100 mmx60 mmø | CF
1156769 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 243.303 | 100 mmx60 mmø | CF
1156856 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 98 | 100 mmx60 mmø | CF
1157188 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 560 | 200 mmx60 mmø | CF
1157315 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 13424.4 | 200 mmx60 mmø | CF
1157587 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 691.072 | 100 mmx60 mmø | cfa
1157589 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 725.894 | 100 mmx60 mmø | CF
1157590 | 100 | RDC | 2826 | 2732.43 | 2868.42 | 2774.86 | 2847.21 | 2753.65 | 2847.21 | 2753.65 | 60 | 100 | 132.319 | 100 mmx60 mmø | CF
1157592 | 60 | RDC | 2713.86 | 2713.86 | 2773.86 | 2773.86 | 2743.86 | 2743.86 | 2743.86 | 2743.86 | 60 | 100 | 265.239 | 100 mmx60 mmø | CF
1157594 | 100 | RDC | 2826 | 2732.43 | 2868.42 | 2774.86 | 2753.65 | 2847.21 | 2847.21 | 2753.65 | 60 | 100 | 132.319 | 100 mmx60 mmø | CF
1157596 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 243.303 | 100 mmx60 mmø | CF
1157598 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 98 | 100 mmx60 mmø | CF
1157662 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 4047 | 200 mmx60 mmø | cfa
1158028 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 502.668 | 100 mmx60 mmø | CF
1158030 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 537.49 | 100 mmx60 mmø | cfa
1158031 | 100 | RDC | 2826 | 2732.43 | 2868.42 | 2774.86 | 2847.21 | 2753.65 | 2847.21 | 2753.65 | 60 | 100 | 132.319 | 100 mmx60 mmø | cfa
1158033 | 60 | RDC | 2713.86 | 2713.86 | 2773.86 | 2773.86 | 2743.86 | 2743.86 | 2743.86 | 2743.86 | 60 | 100 | 265.239 | 100 mmx60 mmø | cfa
1158035 | 100 | RDC | 2826 | 2732.43 | 2868.42 | 2774.86 | 2753.65 | 2847.21 | 2847.21 | 2753.65 | 60 | 100 | 132.319 | 100 mmx60 mmø | cfa
1158037 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 243.303 | 100 mmx60 mmø | cfa
1158039 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 98 | 100 mmx60 mmø | CF
1158096 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 1091.47 | 200 mmx60 mmø | CF
1158184 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 200 | 10133.8 | 200 mmx60 mmø | cfa
1158900 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 1886.02 | 100 mmx60 mmø | CF
1158901 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 1557.18 | 100 mmx60 mmø | cfa
1158902 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 98 | 100 mmx60 mmø | CF
1159244 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 2077.05 | 100 mmx60 mmø | cfa
1159274 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 2122.65 | 100 mmx60 mmø | CF
1159439 | 152.319 | RDC | 2826 | 2718.29 | 2868.42 | 2760.72 | 2847.21 | 2739.5 | 2847.21 | 2739.5 | 60 | 100 | 152.319 | 100 mmx60 mmø | cfa
1159452 | 60 | RDC | 2699.72 | 2699.72 | 2759.72 | 2759.72 | 2729.72 | 2729.72 | 2729.72 | 2729.72 | 60 | 100 | 432.319 | 100 mmx60 mmø | cfa
1159465 | 152.319 | RDC | 2826 | 2718.29 | 2868.42 | 2760.72 | 2739.5 | 2847.21 | 2847.21 | 2739.5 | 60 | 100 | 152.319 | 100 mmx60 mmø | cfa
1159478 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 146.159 | 100 mmx60 mmø | cfa
1175921 | 309 | R-1 | 2977.76 | 2668.76 | 2977.76 | 2668.76 | 2668.76 | 2977.76 | 2977.76 | 2668.76 | 100 | 200 | 309 | 200 mmx100 mmø | CF
1175996 | 100 | R-1 | 2300 | 2300 | 2400 | 2400 | 2350 | 2350 | 2350 | 2350 | 100 | 200 | 4469.82 | 200 mmx100 mmø | CF
1176021 | 781.24 | R-1 | 2199 | 1417.76 | 2199 | 1417.76 | 2199 | 1417.76 | 2199 | 1417.76 | 100 | 200 | 781.24 | 200 mmx100 mmø | CF
1177287 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 691.072 | 100 mmx60 mmø | cfa
1177289 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 725.894 | 100 mmx60 mmø | CF
1177290 | 100 | RDC | 2826 | 2732.43 | 2868.42 | 2774.86 | 2847.21 | 2753.65 | 2847.21 | 2753.65 | 60 | 100 | 132.319 | 100 mmx60 mmø | CF
1177292 | 60 | RDC | 2713.86 | 2713.86 | 2773.86 | 2773.86 | 2743.86 | 2743.86 | 2743.86 | 2743.86 | 60 | 100 | 265.239 | 100 mmx60 mmø | CF
1177294 | 100 | RDC | 2826 | 2732.43 | 2868.42 | 2774.86 | 2753.65 | 2847.21 | 2847.21 | 2753.65 | 60 | 100 | 132.319 | 100 mmx60 mmø | CF
1177296 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 243.303 | 100 mmx60 mmø | CF
1177298 | 60 | RDC | 2827 | 2827 | 2887 | 2887 | 2857 | 2857 | 2857 | 2857 | 60 | 100 | 98 | 100 mmx60 mmø | CF
1210963 | 100 | R-1 | 2467.76 | 2467.76 | 2567.76 | 2567.76 | 2517.76 | 2517.76 | 2517.76 | 2517.76 | 100 | 200 | 32643.5 | 200 mmx100 mmø | CF
1210967 | 100 | R-1 | 2467.76 | 2467.76 | 2567.76 | 2567.76 | 2517.76 | 2517.76 | 2517.76 | 2517.76 | 100 | 200 | 1140.67 | 200 mmx100 mmø | CF
1211012 | 200 | R-1 | 2466.76 | 2333.05 | 2537.47 | 2403.76 | 2368.4 | 2502.12 | 2502.12 | 2368.4 | 100 | 200 | 189.095 | 200 mmx100 mmø | CF
1223159 | 100 | R-1 | 2467.76 | 2467.76 | 2567.76 | 2567.76 | 2517.76 | 2517.76 | 2517.76 | 2517.76 | 100 | 200 | 923.651 | 200 mmx100 mmø | CF
1223199 | 100 | R-1 | 2302.76 | 2302.76 | 2402.76 | 2402.76 | 2352.76 | 2352.76 | 2352.76 | 2352.76 | 100 | 200 | 165.183 | 200 mmx100 mmø | CF
1223200 | 200 | R-1 | 2466.76 | 2333.05 | 2537.47 | 2403.76 | 2368.4 | 2502.12 | 2502.12 | 2368.4 | 100 | 200 | 189.095 | 200 mmx100 mmø | CF
1227951 | 100 | R-1 | 2467.76 | 2467.76 | 2567.76 | 2567.76 | 2517.76 | 2517.76 | 2517.76 | 2517.76 | 100 | 200 | 2028.11 | 200 mmx100 mmø | CF
1227952 | 200 | R-1 | 2466.76 | 2330.29 | 2537.47 | 2401 | 2502.12 | 2365.64 | 2502.12 | 2365.64 | 100 | 200 | 192.998 | 200 mmx100 mmø | CF

# IfcFlowSegment: Gaine circulaire:Circulaire - Té (96)
In: RDC
Type - Autre - Catégorie: Gaine; Nom de la famille: Gaine circulaire
Type - Données d'identification - Nom du type: Circulaire - Té; Sous-projet: Gaine
Type - Génie climatique - Rugosité: 0 mm
Pset_DistributionFlowElementCommon - Reference: Circulaire - Té; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Autre - Famille: Gaine circulaire; Famille et type: Gaine circulaire: Circulaire - Té; ID du type: 805991; Type: Circulaire - Té
Contraintes - Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: RDC
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Verrouillage de la taille: no
Génie climatique - Débit - Débit supplémentaire: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm
Revêtement - Epaisseur du revêtement: 0 mm
Name (Gaine circulaire:Circulaire - Té:...) | Length (mm) = Longueur (mm) | Arase inférieure à son extrémité amont (mm) = Arase inférieure avec isolant à son extrémité amont (mm) | Arase inférieure à son extrémité aval (mm) = Arase inférieure avec isolant à son extrémité aval (mm) | Arase supérieure à son extrémité amont (mm) = Arase supérieure avec isolant à son extrémité amont (mm) | Arase supérieure à son extrémité aval (mm) = Arase supérieure avec isolant à son extrémité aval (mm) | Élévation centrale de départ (mm) = Elévation du milieu (mm) | Élévation centrale de fin (mm) | Elévation de l'axe à son extrémité amont (mm) | Elévation de l'axe à son extrémité aval (mm) | Diamètre (mm) = Diamètre hydraulique (mm) | Taille | Abréviation du système | Classification du système | Nom du système | Surface (m2) | Type de système | Rugosité relative | Trajectoire critique | Débit (m3/s) | Facteur de frottement | Frottement (kg/m2/s2) | Nombre de Reynolds | Perte de pression (Pa) | Pression dynamique (Pa) | Tronçon | Vitesse (m/s) | Taille globale = Taille libre | Group
863985 | 2049.98 | 2684.92 | 2684.92 | 2934.92 | 2934.92 | 2809.92 | 2809.92 | 2809.92 | 2809.92 | 250 | 250ø | S | Soufflage | S 1 | 1.61005 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 1.16427 | 6.93184 | 10 | 3.3953 | 250 mmø | S 1; S 7 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
864071 | 734.971 | 2695 | 2695 | 2945 | 2945 | 2820 | 2820 | 2820 | 2820 | 250 | 250ø | S | Soufflage | S 1 | 0.577245 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 0.417421 | 6.93184 | 10 | 3.3953 | 250 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
864456 | 1169.24 | 2695 | 2695 | 2945 | 2945 | 2820 | 2820 | 2820 | 2820 | 250 | 250ø | S | Soufflage | S 1 | 0.918316 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 0.664059 | 6.93184 | 10 | 3.3953 | 250 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
864469 | 3186.62 | 2695 | 2695 | 2945 | 2945 | 2820 | 2820 | 2820 | 2820 | 250 | 250ø | S | Soufflage | S 1 | 2.50277 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 1.80982 | 6.93184 | 10 | 3.3953 | 250 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
874930 | 20.4095 | 2652.06 | 2637.63 | 2740.45 | 2726.02 | 2696.26 | 2681.82 | 2696.26 | 2681.82 | 125 | 125ø | S | Soufflage | S 1 | 0.00801481 | 0.Soufflage | 0 | no | 0.0416667 | 0.0243586 | 1.3508 | 28279.3 | 0.0275692 | 6.93184 | 11 | 3.3953 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR; Contraintes - Inclinaison: 1
874942 | 1176.52 | 2695 | 2695 | 2945 | 2945 | 2820 | 2820 | 2820 | 2820 | 250 | 250ø | S | Soufflage | S 1 | 0.924034 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 0.668193 | 6.93184 | 10 | 3.3953 | 250 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
874996 | 40.2117 | 2582.71 | 2582.71 | 2707.71 | 2707.71 | 2645.21 | 2645.21 | 2645.21 | 2645.21 | 125 | 125ø | S | Soufflage | S 1 | 0.0157911 | 0.Soufflage | 0 | no | 0.0416667 | 0.0243586 | 1.3508 | 28279.3 | 0.054318 | 6.93184 | 11 | 3.3953 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
875178 | 45.4095 | 2669.74 | 2637.63 | 2758.13 | 2726.02 | 2713.93 | 2681.82 | 2713.93 | 2681.82 | 125 | 125ø | S | Soufflage | S 1 | 0.0178323 | 0.Soufflage | 0 | no | 0.0416667 | 0.0243586 | 1.3508 | 28279.3 | 0.0613393 | 6.93184 | 12 | 3.3953 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR; Contraintes - Inclinaison: 1
875182 | 40.2117 | 2582.71 | 2582.71 | 2707.71 | 2707.71 | 2645.21 | 2645.21 | 2645.21 | 2645.21 | 125 | 125ø | S | Soufflage | S 1 | 0.0157911 | 0.Soufflage | 0 | no | 0.0416667 | 0.0243586 | 1.3508 | 28279.3 | 0.054318 | 6.93184 | 12 | 3.3953 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
875196 | 65.4095 | 2683.88 | 2637.63 | 2772.27 | 2726.02 | 2728.08 | 2681.82 | 2728.08 | 2681.82 | 125 | 125ø | S | Soufflage | S 1 | 0.0256863 | 0.Soufflage | 0 | no | 0.0416667 | 0.0243586 | 1.3508 | 28279.3 | 0.0883553 | 6.93184 | 13 | 3.3953 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR; Contraintes - Inclinaison: 1
875200 | 40.2117 | 2582.71 | 2582.71 | 2707.71 | 2707.71 | 2645.21 | 2645.21 | 2645.21 | 2645.21 | 125 | 125ø | S | Soufflage | S 1 | 0.0157911 | 0.Soufflage | 0 | no | 0.0416667 | 0.0243586 | 1.3508 | 28279.3 | 0.054318 | 6.93184 | 13 | 3.3953 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
875218 | 82.9095 | 2696.26 | 2637.63 | 2784.64 | 2726.02 | 2740.45 | 2681.82 | 2740.45 | 2681.82 | 125 | 125ø | S | Soufflage | S 1 | 0.0325585 | 0.Soufflage | 0 | no | 0.0138889 | 0.0320578 | 0.197528 | 9426.42 | 0.016377 | 0.770205 | 4 | 1.13177 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR; Contraintes - Inclinaison: 1
875222 | 40.2117 | 2582.71 | 2582.71 | 2707.71 | 2707.71 | 2645.21 | 2645.21 | 2645.21 | 2645.21 | 125 | 125ø | S | Soufflage | S 1 | 0.0157911 | 0.Soufflage | 0 | no | 0.0138889 | 0.0320578 | 0.197528 | 9426.42 | 0.00794295 | 0.770205 | 4 | 1.13177 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
875236 | 70.4095 | 2687.42 | 2637.63 | 2775.81 | 2726.02 | 2731.61 | 2681.82 | 2731.61 | 2681.82 | 125 | 125ø | S | Soufflage | S 1 | 0.0276498 | 0.Soufflage | 0 | no | 0.0138889 | 0.0320578 | 0.197528 | 9426.42 | 0.0139079 | 0.770205 | 3 | 1.13177 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR; Contraintes - Inclinaison: 1
875240 | 40.2117 | 2582.71 | 2582.71 | 2707.71 | 2707.71 | 2645.21 | 2645.21 | 2645.21 | 2645.21 | 125 | 125ø | S | Soufflage | S 1 | 0.0157911 | 0.Soufflage | 0 | no | 0.0138889 | 0.0320578 | 0.197528 | 9426.42 | 0.00794295 | 0.770205 | 3 | 1.13177 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
875264 | 862.5 | 2757.5 | 2757.5 | 2882.5 | 2882.5 | 2820 | 2820 | 2820 | 2820 | 125 | 125ø | S | Soufflage | S 1 | 0.338703 | 0.Soufflage | 0 | no | 0.0138889 | 0.0320578 | 0.197528 | 9426.42 | 0.170368 | 0.770205 | 3 | 1.13177 | 125 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
875319 | 1625 | 2740 | 2740 | 2900 | 2900 | 2820 | 2820 | 2820 | 2820 | 160 | 160ø | S | Soufflage | S 1 | 0.816814 | 0.Soufflage | 0 | no | 0.0416667 | 0.0286733 | 0.418162 | 22093.2 | 0.561119 | 2.58231 | 5 | 2.07233 | 160 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
875518 | 3735 | 2740 | 2740 | 2900 | 2900 | 2820 | 2820 | 2820 | 2820 | 160 | 160ø | S | Soufflage | S 1 | 1.87742 | 0.Soufflage | 0 | no | 0.0833333 | 0.021787 | 1.40652 | 44186.3 | 5.25336 | 10.3293 | 6 | 4.14466 | 160 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
875614 | 725 | 2720 | 2720 | 2920 | 2920 | 2820 | 2820 | 2820 | 2820 | 200 | 200ø | S | Soufflage | S 1 | 0.455531 | 0.Soufflage | 0 | no | 0.125 | 0.0208163 | 0.990795 | 53023.6 | 0.718327 | 9.51944 | 8 | 3.97887 | 200 mmø | S 1 | Données d'identification - AI_Zone CLIM: BUREAUX SDR
880602 | 7153.19 | 2750 | 2750 | 2950 | 2950 | 2850 | 2850 | 2850 | 2850 | 200 | 200ø | S | Soufflage | S 2 | 4.49448 | 0.Soufflage | 0 | yes | 0.0555556 | 0.0303184 | 0.239698 | 23566.1 | 0.526001 | 1.88038 | 5 | 1.76839 | 200 mmø | S 2 | Données d'identification - AI_Zone CLIM: OPEN SPACE
880705 | 159.471 | 2550 | 2550 | 2800 | 2800 | 2675 | 2675 | 2675 | 2675 | 250 | 250ø | S | Soufflage | S 3 | 0.125248 | 0.Soufflage |  |  |  |  |  |  |  |  |  |  | 250 mmø | S 3 | Données d'identification - AI_Zone CLIM: OPEN SPACE
880914 | 79.4495 | 2517.5 | 2517.5 | 2832.5 | 2832.5 | 2675 | 2675 | 2675 | 2675 | 315 | 315ø | S | Soufflage | S 4 | 0.0786234 | 0.Soufflage | 0 | yes | 0.1875 | 0.0210717 | 0.232842 | 50498.7 | 0.0184992 | 3.48074 | 1 | 2.40597 | 315 mmø | S 4 | Données d'identification - AI_Zone CLIM: OPEN SPACE
881105 | 162.755 | 2550 | 2550 | 2800 | 2800 | 2675 | 2675 | 2675 | 2675 | 250 | 250ø | S | Soufflage | S 2 | 0.127827 | 0.Soufflage | 0 | yes | 0.111111 | 0.0226683 | 0.279347 | 37705.7 | 0.045465 | 3.08082 | 6 | 2.26354 | 250 mmø | S 2 | Données d'identification - AI_Zone CLIM: OPEN SPACE
881917 | 1896.44 | 2700 | 2700 | 2950 | 2950 | 2825 | 2825 | 2825 | 2825 | 250 | 250ø | S | Soufflage | S 2 | 1.48946 | 0.Soufflage | 0 | yes | 0.111111 | 0.0226683 | 0.279347 | 37705.7 | 0.529766 | 3.08082 | 6 | 2.26354 | 250 mmø | S 2 | Données d'identification - AI_Zone CLIM: OPEN SPACE
887145 | 6937.43 | 2700 | 2700 | 2900 | 2900 | 2800 | 2800 | 2800 | 2800 | 200 | 200ø | S | Soufflage | S 4 | 4.35892 | 0.Soufflage | 0 | yes | 0.0763889 | 0.0286733 | 0.418499 | 32403.3 | 1.77966 | 3.5551 | 7 | 2.43153 | 200 mmø | S 4 | Données d'identification - AI_Zone CLIM: OPEN SPACE
887242 | 5789.58 | 2675 | 2675 | 2925 | 2925 | 2800 | 2800 | 2800 | 2800 | 250 | 250ø | S | Soufflage | S 4 | 4.54712 | 0.Soufflage | 0 | yes | 0.159722 | 0.0223273 | 0.527179 | 54201.9 | 2.79129 | 6.36622 | 4 | 3.25383 | 250 mmø | S 4 | Données d'identification - AI_Zone CLIM: OPEN SPACE
887290 | 6601.46 | 2700 | 2700 | 2950 | 2950 | 2825 | 2825 | 2825 | 2825 | 250 | 250ø | S | Soufflage | S 2 | 5.18477 | 0.Soufflage | 0 | yes | 0.111111 | 0.0269573 | 0.279347 | 37705.7 | 0.669035 | 3.08082 | 6 | 2.26354 | 250 mmø | S 2 | Données d'identification - AI_Zone CLIM: OPEN SPACE
923404 | 149.218 | 2735.82 | 2586.6 | 2735.82 | 2586.6 | 2586.6 | 2735.82 | 2735.82 | 2586.6 | 125 | 125ø | VMC | Extraction d'air | VMC 1 | 0.0585978 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.0245118 | 0.623866 | 29 | 1.01859 | 125 mmø | VMC 1
923429 | 2201.17 | 2798.32 | 2798.32 | 2923.32 | 2923.32 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 125 | 125ø | VMC | Extraction d'air | VMC 1 | 0.864396 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.361582 | 0.623866 | 29 | 1.01859 | 125 mmø | VMC 1; VMC 2
923477 | 149.218 | 2735.82 | 2586.6 | 2735.82 | 2586.6 | 2735.82 | 2586.6 | 2735.82 | 2586.6 | 125 | 125ø | VMC | Extraction d'air | VMC 2 | 0.0585978 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.0245118 | 0.623866 | 1 | 1.01859 | 125 mmø | VMC 2
923601 | 144.218 | 2730.82 | 2586.6 | 2730.82 | 2586.6 | 2586.6 | 2730.82 | 2730.82 | 2586.6 | 125 | 125ø | VMC | Extraction d'air | VMC 2 | 0.0566343 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.0236905 | 0.623866 | 30 | 1.01859 | 125 mmø | VMC 2
923603 | 2255.01 | 2780.82 | 2780.82 | 2940.82 | 2940.82 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 160 | 160ø | VMC | Extraction d'air | VMC 2 | 1.13349 | 0.Extraction (VMC) | 0 | no | 0.05 | 0.0247548 | 0.575323 | 26511.8 | 1.29736 | 3.71853 | 5 | 2.4868 | 160 mmø | VMC 2
923607 | 234.677 | 2798.32 | 2798.32 | 2923.32 | 2923.32 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 125 | 125ø | VMC | Extraction d'air | VMC 2 | 0.0921575 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.03855 | 0.623866 | 1 | 1.01859 | 125 mmø | VMC 2
923681 | 144.218 | 2730.82 | 2586.6 | 2730.82 | 2586.6 | 2586.6 | 2730.82 | 2730.82 | 2586.6 | 125 | 125ø | VMC | Extraction d'air | VMC 2 | 0.0566343 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.0236905 | 0.623866 | 28 | 1.01859 | 125 mmø | VMC 2
923683 | 525.606 | 2780.82 | 2780.82 | 2940.82 | 2940.82 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 160 | 160ø | VMC | Extraction d'air | VMC 2 | 0.264198 | 0.Extraction (VMC) | 0 | no | 0.075 | 0.0223685 | 1.16969 | 39767.7 | 0.614797 | 8.36669 | 7 | 3.73019 | 160 mmø | VMC 2; VMC 8
923872 | 332.547 | 2555.97 | 2555.97 | 2680.97 | 2680.97 | 2618.47 | 2618.47 | 2618.47 | 2618.47 | 125 | 125ø | VMC | Extraction d'air | VMC 2 | 0.130591 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.0546269 | 0.623866 | 31 | 1.01859 | 125 mmø | VMC 2
923905 | 4.85154 | 2748.32 | 2743.47 | 2748.32 | 2743.47 | 2743.47 | 2748.32 | 2748.32 | 2743.47 | 125 | 125ø | VMC | Extraction d'air | VMC 2 | 0.0019052 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.000796955 | 0.623866 | 31 | 1.01859 | 125 mmø | VMC 2
923937 | 392.749 | 2798.32 | 2798.32 | 2923.32 | 2923.32 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 125 | 125ø | VMC | Extraction d'air | VMC 2 | 0.154232 | 0.Extraction (VMC) | 0 | no | 0.025 | 0.0276768 | 0.552531 | 16967.6 | 0.217006 | 2.49546 | 2 | 2.03718 | 125 mmø | VMC 2
924344 | 352.296 | 2418 | 2418 | 2618 | 2618 | 2518 | 2518 | 2518 | 2518 | 200 | 200ø | VMC | Extraction d'air | VMC 8 | 0.221354 | 0.Extraction (VMC) | 0 | no | 0.0875 | 0.0227577 | 0.530769 | 37116.5 | 0.186988 | 4.66452 | 9 | 2.78521 | 200 mmø | VMC 8
924413 | 66.8467 | 2760.82 | 2760.82 | 2960.82 | 2960.82 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 200 | 200ø | VMC | Extraction d'air | VMC 8 | 0.042001 | 0.Extraction (VMC) | 0 | no | 0.0875 | 0.0227577 | 0.530769 | 37116.5 | 0.0354802 | 4.66452 | 9 | 2.78521 | 200 mmø | VMC 8
924439 | 3811.77 | 2684.9 | 2684.9 | 2934.9 | 2934.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 250 | 250ø | VMC | Extraction d'air | VMC 8 | 2.99376 | 0.Extraction (VMC) | 0 | no | 0.125 | 0.0220105 | 0.34329 | 42418.9 | 1.30854 | 3.89916 | 14 | 2.54648 | 250 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
924512 | 112.607 | 2798.32 | 2798.32 | 2923.32 | 2923.32 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 125 | 125ø | VMC | Extraction d'air | VMC 8 | 0.0442205 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.0184977 | 0.623866 | 11 | 1.01859 | 125 mmø | VMC 8
924622 | 319.129 | 2731.53 | 2505.87 | 2872.95 | 2647.29 | 2802.24 | 2576.58 | 2802.24 | 2576.58 | 200 | 200ø | VMC | Extraction d'air | VMC 8 | 0.200515 | 0.Extraction (VMC) | 0 | no | 0.0875 | 0.0227577 | 0.530769 | 37116.5 | 0.169384 | 4.66452 | 9 | 2.78521 | 200 mmø | VMC 8 | Contraintes - Inclinaison: 1
926332 | 146.686 | 2418 | 2418 | 2618 | 2618 | 2518 | 2518 | 2518 | 2518 | 200 | 200ø | VMC | Extraction d'air | VMC 8 | 0.0921654 | 0.Extraction (VMC) | 0 | no | 0.0875 | 0.0227577 | 0.530769 | 37116.5 | 0.0778563 | 4.66452 | 9 | 2.78521 | 200 mmø | VMC 8
926333 | 319.129 | 2731.53 | 2505.87 | 2872.95 | 2647.29 | 2576.58 | 2802.24 | 2802.24 | 2576.58 | 200 | 200ø | VMC | Extraction d'air | VMC 8 | 0.200515 | 0.Extraction (VMC) | 0 | no | 0.0875 | 0.0227577 | 0.530769 | 37116.5 | 0.169384 | 4.66452 | 9 | 2.78521 | 200 mmø | VMC 8 | Contraintes - Inclinaison: 1
926701 | 329.212 | 2760.82 | 2760.82 | 2960.82 | 2960.82 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 200 | 200ø | VMC | Extraction d'air | VMC 8 | 0.20685 | 0.Extraction (VMC) | 0 | no | 0.0875 | 0.0227577 | 0.530769 | 37116.5 | 0.174736 | 4.66452 | 9 | 2.78521 | 200 mmø | VMC 8
940511 | 1228.94 | 2684.9 | 2684.9 | 2934.9 | 2934.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 250 | 250ø | VMC | Extraction d'air | VMC 8 | 0.965206 | 0.Extraction (VMC) | 0 | no | 0.1875 | 0.0198887 | 0.697945 | 63628.3 | 0.857732 | 8.77311 | 19 | 3.81972 | 250 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
940602 | 327.481 | 3387.38 | 3059.9 | 3387.38 | 3059.9 | 3059.9 | 3387.38 | 3387.38 | 3059.9 | 250 | 250ø | VMC | Extraction d'air | VMC 8 | 0.257203 | 0.Extraction (VMC) | 0 | no | 0.1875 | 0.0198887 | 0.697945 | 63628.3 | 0.228564 | 8.77311 | 19 | 3.81972 | 250 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
940656 | 29.4045 | 2684.9 | 2684.9 | 2934.9 | 2934.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 250 | 250ø | S | Soufflage | S 6 | 0.0230942 | 0.Soufflage | 0 | no | 0 | 0 | 0 | 0 | 0 | 0 | 1 | 0 | 250 mmø | S 6 | Données d'identification - AI_Zone CLIM: EXISTANT; AI_Phase: EXISTANT
940658 | 378.4 | 3438.3 | 3059.9 | 3438.3 | 3059.9 | 3059.9 | 3438.3 | 3438.3 | 3059.9 | 250 | 250ø | S | Soufflage | S 6 | 0.297194 | 0.Soufflage | 0 | no | 0 | 0 | 0 | 0 | 0 | 0 | 1 | 0 | 250 mmø | S 6 | Données d'identification - AI_Zone CLIM: EXISTANT; AI_Phase: EXISTANT
940730 | 2349.85 | 2684.9 | 2684.9 | 2934.9 | 2934.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 250 | 250ø | S | Soufflage | S 6 | 1.84557 | 0.Soufflage | 0 | no | 0 | 0 | 0 | 0 | 0 | 0 | 1 | 0 | 250 mmø | S 6 | Données d'identification - AI_Zone CLIM: EXISTANT; AI_Phase: EXISTANT
940771 | 29.4153 | 2684.9 | 2684.9 | 2934.9 | 2934.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 250 | 250ø | S | Soufflage | S 7 | 0.0231027 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 0.0167062 | 6.93184 | 10 | 3.3953 | 250 mmø | S 7 | Données d'identification - AI_Zone CLIM: EXISTANT; AI_Phase: EXISTANT
940773 | 378.4 | 3438.3 | 3059.9 | 3438.3 | 3059.9 | 3059.9 | 3438.3 | 3438.3 | 3059.9 | 250 | 250ø | S | Soufflage | S 7 | 0.297194 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 0.214909 | 6.93184 | 10 | 3.3953 | 250 mmø | S 7 | Données d'identification - AI_Zone CLIM: BUREAUX SDR; AI_Phase: EXISTANT
940948 | 3034.69 | 2684.92 | 2684.9 | 2934.92 | 2934.9 | 2809.92 | 2809.9 | 2809.92 | 2809.9 | 250 | 250ø | S | Soufflage | S 7 | 2.38344 | 0.Soufflage | 0 | no | 0.166667 | 0.0204831 | 0.567942 | 56558.5 | 1.72353 | 6.93184 | 10 | 3.3953 | 250 mmø | S 7 | Données d'identification - AI_Zone CLIM: EXISTANT; AI_Phase: EXISTANT
941036 | 9.21813 | 2634.9 | 2625.68 | 2634.9 | 2625.68 | 2625.68 | 2634.9 | 2634.9 | 2625.68 | 125 | 125ø | VMC | Extraction d'air | VMC 8 | 0.00361995 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.00151425 | 0.623866 | 20 | 1.01859 | 125 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941067 | 737.327 | 2684.9 | 2684.9 | 2934.9 | 2934.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 250 | 250ø | VMC | Extraction d'air | VMC 8 | 0.579095 | 0.Extraction (VMC) | 0 | no | 0.175 | 0.0202348 | 0.618565 | 59386.4 | 0.456085 | 7.64236 | 18 | 3.56507 | 250 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941081 | 9.21813 | 2634.9 | 2625.68 | 2634.9 | 2625.68 | 2625.68 | 2634.9 | 2634.9 | 2625.68 | 125 | 125ø | VMC | Extraction d'air | VMC 8 | 0.00361995 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.00151425 | 0.623866 | 21 | 1.01859 | 125 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941175 | 787.027 | 2684.9 | 2684.9 | 2934.9 | 2934.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 250 | 250ø | VMC | Extraction d'air | VMC 8 | 0.61813 | 0.Extraction (VMC) | 0 | no | 0.1625 | 0.0206131 | 0.543328 | 55144.6 | 0.427614 | 6.58958 | 17 | 3.31042 | 250 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941223 | 9.21813 | 2634.9 | 2625.68 | 2634.9 | 2625.68 | 2625.68 | 2634.9 | 2634.9 | 2625.68 | 125 | 125ø | VMC | Extraction d'air | VMC 8 | 0.00361995 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.00151425 | 0.623866 | 22 | 1.01859 | 125 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941230 | 9.21813 | 2634.9 | 2625.68 | 2634.9 | 2625.68 | 2625.68 | 2634.9 | 2634.9 | 2625.68 | 125 | 125ø | VMC | Extraction d'air | VMC 8 | 0.00361995 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.00151425 | 0.623866 | 23 | 1.01859 | 125 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941265 | 726.708 | 2684.9 | 2684.9 | 2934.9 | 2934.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 250 | 250ø | VMC | Extraction d'air | VMC 8 | 0.570755 | 0.Extraction (VMC) | 0 | no | 0.15 | 0.0210298 | 0.472312 | 50902.7 | 0.343233 | 5.61479 | 16 | 3.05577 | 250 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941317 | 600.788 | 2684.9 | 2684.9 | 2934.9 | 2934.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 250 | 250ø | VMC | Extraction d'air | VMC 8 | 0.471857 | 0.Extraction (VMC) | 0 | no | 0.1375 | 0.0214923 | 0.405601 | 46660.8 | 0.24368 | 4.71799 | 15 | 2.80113 | 250 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941452 | 9.21813 | 2634.9 | 2625.68 | 2634.9 | 2625.68 | 2625.68 | 2634.9 | 2634.9 | 2625.68 | 125 | 125ø | VMC | Extraction d'air | VMC 8 | 0.00361995 | 0.Extraction (VMC) | 0 | no | 0.0125 | 0.0329134 | 0.164268 | 8483.78 | 0.00151425 | 0.623866 | 24 | 1.01859 | 125 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941517 | 98.604 | 2684.9 | 2684.9 | 2934.9 | 2934.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 250 | 250ø | VMC | Extraction d'air | VMC 8 | 0.0774434 | 0.Extraction (VMC) | 0 | no | 0.125 | 0.0220105 | 0.34329 | 42418.9 | 0.0338498 | 3.89916 | 14 | 2.54648 | 250 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941612 | 9.21813 | 2634.9 | 2625.68 | 2634.9 | 2625.68 | 2625.68 | 2634.9 | 2634.9 | 2625.68 | 125 | 125ø | VMC | Extraction d'air | VMC 8 | 0.00361995 | 0.Extraction (VMC) | 0 | no | 0.025 | 0.0276768 | 0.552531 | 16967.6 | 0.0050933 | 2.49546 | 25 | 2.03718 | 125 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
941634 | 58.1459 | 2709.9 | 2709.9 | 2909.9 | 2909.9 | 2809.9 | 2809.9 | 2809.9 | 2809.9 | 200 | 200ø | VMC | Extraction d'air | VMC 8 | 0.0365341 | 0.Extraction (VMC) | 0 | no | 0.1 | 0.0220105 | 0.670489 | 42418.9 | 0.0389861 | 6.09244 | 12 | 3.1831 | 200 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
942232 | 144.072 | 2757.41 | 2720.12 | 2950.6 | 2913.31 | 2816.71 | 2854 | 2854 | 2816.71 | 200 | 200ø | VMC | Extraction d'air | VMC 8 | 0.0905228 | 0.Extraction (VMC) | 0 | no | 0.1 | 0.0220105 | 0.670489 | 42418.9 | 0.0965983 | 6.09244 | 12 | 3.1831 | 200 mmø | VMC 8 | Contraintes - Inclinaison: 0.267949; Données d'identification - AI_Phase: EXISTANT
942273 | 214.226 | 2760.82 | 2760.82 | 2960.82 | 2960.82 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 200 | 200ø | VMC | Extraction d'air | VMC 8 | 0.134602 | 0.Extraction (VMC) | 0 | no | 0.1 | 0.0220105 | 0.670489 | 42418.9 | 0.143636 | 6.09244 | 12 | 3.1831 | 200 mmø | VMC 8
942520 | 960.048 | 2760.82 | 2760.82 | 2960.82 | 2960.82 | 2860.82 | 2860.82 | 2860.82 | 2860.82 | 200 | 200ø | VMC | Extraction d'air | VMC 8 | 0.603216 | 0.Extraction (VMC) | 0 | no | 0.1 | 0.0220105 | 0.670489 | 42418.9 | 0.643701 | 6.09244 | 12 | 3.1831 | 200 mmø | VMC 8 | Données d'identification - AI_Phase: EXISTANT
