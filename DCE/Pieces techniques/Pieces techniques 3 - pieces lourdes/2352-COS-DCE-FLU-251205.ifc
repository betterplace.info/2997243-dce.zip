Properties of the parts of a building model (IFC2X3), part 2 of 8

# IfcDistributionPort (2497)
Name | FlowDirection | Group
Port_1198239_0 | SOURCEANDSINK | GEN 3
Port_1159905_1 | SOURCEANDSINK
Port_1159906_1 | SOURCEANDSINK
Port_1159907_1 | SOURCEANDSINK
Port_1159908_1 | SOURCEANDSINK
Port_1159909_1 | SOURCEANDSINK
Port_1159910_1 | SOURCEANDSINK
Port_1160071_1 | SOURCEANDSINK
Port_1160072_1 | SOURCEANDSINK
Port_1160073_1 | SOURCEANDSINK
Port_1160074_1 | SOURCEANDSINK
Port_1160075_1 | SOURCEANDSINK
Port_1160076_1 | SOURCEANDSINK
Port_1160225_1 | SOURCEANDSINK
Port_1160226_1 | SOURCEANDSINK
Port_1160227_1 | SOURCEANDSINK
Port_1160228_1 | SOURCEANDSINK
Port_1160229_1 | SOURCEANDSINK
Port_1160230_1 | SOURCEANDSINK
Port_1160328_1 | SOURCEANDSINK
Port_1160329_1 | SOURCEANDSINK
Port_1160330_1 | SOURCEANDSINK
Port_1160331_1 | SOURCEANDSINK
Port_1160332_1 | SOURCEANDSINK
Port_1160333_1 | SOURCEANDSINK
Port_1160389_1 | SOURCEANDSINK
Port_1160390_1 | SOURCEANDSINK
Port_1160391_1 | SOURCEANDSINK
Port_1160392_1 | SOURCEANDSINK
Port_1160393_1 | SOURCEANDSINK
Port_1160394_1 | SOURCEANDSINK
Port_1160486_1 | SOURCEANDSINK
Port_1160487_1 | SOURCEANDSINK
Port_1160488_1 | SOURCEANDSINK
Port_1160489_1 | SOURCEANDSINK
Port_1160490_1 | SOURCEANDSINK
Port_1160491_1 | SOURCEANDSINK
Port_1160619_0 | SOURCEANDSINK | GEN 4
Port_1160619_1 | SOURCEANDSINK | GEN 4
Port_1160977_1 | SOURCEANDSINK
Port_1160978_1 | SOURCEANDSINK
Port_1160979_1 | SOURCEANDSINK
Port_1160980_1 | SOURCEANDSINK
Port_1160981_1 | SOURCEANDSINK
Port_1160982_1 | SOURCEANDSINK
Port_1161099_1 | SOURCEANDSINK
Port_1161100_1 | SOURCEANDSINK
Port_1161101_1 | SOURCEANDSINK
Port_1161102_1 | SOURCEANDSINK
Port_1161103_1 | SOURCEANDSINK
Port_1161104_1 | SOURCEANDSINK
Port_1161214_1 | SOURCEANDSINK
Port_1161215_1 | SOURCEANDSINK
Port_1161216_1 | SOURCEANDSINK
Port_1161217_1 | SOURCEANDSINK
Port_1161218_1 | SOURCEANDSINK
Port_1161219_1 | SOURCEANDSINK
Port_1161312_1 | SOURCEANDSINK
Port_1161313_1 | SOURCEANDSINK
Port_1161314_1 | SOURCEANDSINK
Port_1161315_1 | SOURCEANDSINK
Port_1161316_1 | SOURCEANDSINK
Port_1161317_1 | SOURCEANDSINK
Port_1161366_1 | SOURCEANDSINK
Port_1161367_1 | SOURCEANDSINK
Port_1161368_1 | SOURCEANDSINK
Port_1161369_1 | SOURCEANDSINK
Port_1161370_1 | SOURCEANDSINK
Port_1161371_1 | SOURCEANDSINK
Port_1161451_1 | SOURCEANDSINK
Port_1161452_1 | SOURCEANDSINK
Port_1161453_1 | SOURCEANDSINK
Port_1161454_1 | SOURCEANDSINK
Port_1161455_1 | SOURCEANDSINK
Port_1161456_1 | SOURCEANDSINK
Port_1161505_1 | SOURCEANDSINK
Port_1161506_1 | SOURCEANDSINK
Port_1161507_1 | SOURCEANDSINK
Port_1161508_1 | SOURCEANDSINK
Port_1161509_1 | SOURCEANDSINK
Port_1161510_1 | SOURCEANDSINK
Port_1161631_0 | SOURCEANDSINK | GEN 5
Port_1161631_1 | SOURCEANDSINK | GEN 5
Port_1161731_1 | SOURCEANDSINK
Port_1161739_1 | SOURCEANDSINK
Port_1174640_1 | SOURCEANDSINK
Port_1175921_0 | SOURCEANDSINK
Port_1223210_1 | SOURCEANDSINK
Port_1175921_1 | SOURCEANDSINK
Port_1175996_0 | SOURCEANDSINK
Port_1227962_2 | SOURCEANDSINK
Port_1175996_1 | SOURCEANDSINK
Port_1227964_2 | SOURCEANDSINK
Port_1176021_0 | SOURCEANDSINK
Port_1227962_1 | SOURCEANDSINK
Port_1176021_1 | SOURCEANDSINK
Port_1176224_1 | SOURCEANDSINK
Port_1176458_1 | SOURCEANDSINK
Port_1176606_1 | SOURCEANDSINK
Port_1176607_1 | SOURCEANDSINK
Port_1176637_1 | SOURCEANDSINK
Port_1176638_1 | SOURCEANDSINK
Port_1176734_1 | SOURCEANDSINK
Port_1176735_1 | SOURCEANDSINK
Port_1176806_1 | SOURCEANDSINK
Port_1176977_1 | SOURCEANDSINK
Port_1177287_0 | SOURCEANDSINK
Port_1177300_1 | SOURCEANDSINK
Port_1177287_1 | SOURCEANDSINK
Port_1177288_3 | SOURCEANDSINK
Port_1177289_0 | SOURCEANDSINK
Port_1177299_2 | SOURCEANDSINK
Port_1177289_1 | SOURCEANDSINK
Port_1177291_1 | SOURCEANDSINK
Port_1177290_0 | SOURCEANDSINK
Port_1177291_2 | SOURCEANDSINK
Port_1177290_1 | SOURCEANDSINK
Port_1177293_1 | SOURCEANDSINK
Port_1177292_0 | SOURCEANDSINK
Port_1177293_2 | SOURCEANDSINK
Port_1177292_1 | SOURCEANDSINK
Port_1177295_1 | SOURCEANDSINK
Port_1177294_0 | SOURCEANDSINK
Port_1177295_2 | SOURCEANDSINK
Port_1177294_1 | SOURCEANDSINK
Port_1177445_1 | SOURCEANDSINK
Port_1177296_0 | SOURCEANDSINK
Port_1177445_2 | SOURCEANDSINK
Port_1177298_0 | SOURCEANDSINK
Port_1177299_1 | SOURCEANDSINK
Port_1177298_1 | SOURCEANDSINK
Port_1177300_2 | SOURCEANDSINK
Port_1177532_1 | SOURCEANDSINK
Port_1177580_1 | SOURCEANDSINK
Port_1177635_1 | SOURCEANDSINK
Port_1177878_1 | SOURCEANDSINK
Port_1177920_1 | SOURCEANDSINK
Port_1177996_1 | SOURCEANDSINK
Port_1178285_1 | SOURCEANDSINK
Port_1178637_1 | SOURCEANDSINK
Port_1178691_1 | SOURCEANDSINK
Port_1178899_1 | SOURCEANDSINK
Port_1178914_1 | SOURCEANDSINK
Port_1178950_1 | SOURCEANDSINK
Port_1178951_1 | SOURCEANDSINK
Port_1178952_1 | SOURCEANDSINK
Port_1178971_1 | SOURCEANDSINK
Port_1179108_1 | SOURCEANDSINK
Port_1179196_1 | SOURCEANDSINK
Port_1179197_1 | SOURCEANDSINK
Port_1179207_1 | SOURCEANDSINK
Port_1179208_1 | SOURCEANDSINK
Port_1179236_1 | SOURCEANDSINK
Port_1179237_1 | SOURCEANDSINK
InPort_1179252_0 | SINK | VMC 5
OutPort_1179251_1 | SOURCE | VMC 5
InPort_1216867_1 | SINK | VMC 5
OutPort_1179252_1 | SOURCE | VMC 5
InPort_1179254_0 | SINK | VMC 5
OutPort_1216867_2 | SOURCE | VMC 5
Port_1179533_2 | SOURCEANDSINK
Port_1179626_2 | SOURCEANDSINK
Port_1181137_2 | SOURCEANDSINK
Port_1181183_2 | SOURCEANDSINK
Port_1181184_2 | SOURCEANDSINK
Port_1181291_2 | SOURCEANDSINK
Port_1181409_2 | SOURCEANDSINK
Port_1181410_2 | SOURCEANDSINK
Port_1181411_2 | SOURCEANDSINK
Port_1181412_2 | SOURCEANDSINK
Port_1181438_2 | SOURCEANDSINK
Port_1181439_2 | SOURCEANDSINK
Port_1181440_2 | SOURCEANDSINK
Port_1181441_2 | SOURCEANDSINK
Port_1181474_2 | SOURCEANDSINK
Port_1181475_2 | SOURCEANDSINK
Port_1181476_2 | SOURCEANDSINK
Port_1181477_2 | SOURCEANDSINK
Port_1181493_2 | SOURCEANDSINK
Port_1181494_2 | SOURCEANDSINK
Port_1181495_2 | SOURCEANDSINK
Port_1181496_2 | SOURCEANDSINK
Port_1181527_1 | SOURCEANDSINK
Port_1184762_1 | SOURCEANDSINK
Port_1184840_1 | SOURCEANDSINK
Port_1184910_1 | SOURCEANDSINK
Port_1184911_1 | SOURCEANDSINK
Port_1184942_1 | SOURCEANDSINK
Port_1187469_2 | SOURCEANDSINK
Port_1187620_2 | SOURCEANDSINK
Port_1187769_2 | SOURCEANDSINK
Port_1187840_2 | SOURCEANDSINK
Port_1188031_2 | SOURCEANDSINK
Port_1188375_2 | SOURCEANDSINK
Port_1188670_2 | SOURCEANDSINK
Port_1194219_1 | SOURCEANDSINK
Port_1194253_1 | SOURCEANDSINK
Port_1194263_1 | SOURCEANDSINK
Port_1194271_1 | SOURCEANDSINK
Port_1194279_1 | SOURCEANDSINK
Port_1194335_1 | SOURCEANDSINK
Port_1194611_1 | SOURCEANDSINK
Port_1194713_1 | SOURCEANDSINK
Port_1194716_1 | SOURCEANDSINK
Port_1194724_1 | SOURCEANDSINK
Port_1194727_1 | SOURCEANDSINK
Port_1194741_1 | SOURCEANDSINK
Port_1194744_1 | SOURCEANDSINK
Port_1194754_1 | SOURCEANDSINK
Port_1194757_1 | SOURCEANDSINK
Port_1194765_1 | SOURCEANDSINK
Port_1194768_1 | SOURCEANDSINK
Port_1194789_1 | SOURCEANDSINK
Port_1194792_1 | SOURCEANDSINK
Port_1194802_1 | SOURCEANDSINK
Port_1194805_1 | SOURCEANDSINK
Port_1194817_1 | SOURCEANDSINK
Port_1194820_1 | SOURCEANDSINK
Port_1194887_2 | SOURCEANDSINK
Port_1195043_1 | SOURCEANDSINK
Port_1195094_1 | SOURCEANDSINK
Port_1195130_1 | SOURCEANDSINK | EGA 1
Port_1195132_1 | SOURCEANDSINK | EGA 1
Port_1195150_2 | SOURCEANDSINK | EGA 1
Port_1195152_1 | SOURCEANDSINK | EGA 1
Port_1195289_1 | SOURCEANDSINK
Port_1195342_1 | SOURCEANDSINK
Port_1195764_1 | SOURCEANDSINK
Port_1195799_1 | SOURCEANDSINK
Port_1195819_1 | SOURCEANDSINK
Port_1195857_1 | SOURCEANDSINK
Port_1195986_1 | SOURCEANDSINK
Port_1196026_1 | SOURCEANDSINK
Port_1196045_1 | SOURCEANDSINK
Port_1196076_1 | SOURCEANDSINK
Port_1196107_1 | SOURCEANDSINK
Port_1196128_1 | SOURCEANDSINK
Port_1196148_1 | SOURCEANDSINK
Port_1196192_1 | SOURCEANDSINK
Port_1196231_1 | SOURCEANDSINK
Port_1196268_1 | SOURCEANDSINK
Port_1196318_1 | SOURCEANDSINK
Port_1196373_1 | SOURCEANDSINK
Port_1196423_1 | SOURCEANDSINK
Port_1196424_1 | SOURCEANDSINK
Port_1196604_1 | SOURCEANDSINK
Port_1196605_1 | SOURCEANDSINK
Port_1196626_1 | SOURCEANDSINK
Port_1196627_1 | SOURCEANDSINK
Port_1196655_1 | SOURCEANDSINK
Port_1196763_1 | SOURCEANDSINK
Port_1196949_1 | SOURCEANDSINK
Port_1197007_1 | SOURCEANDSINK
Port_1197044_1 | SOURCEANDSINK
Port_1197087_1 | SOURCEANDSINK
Port_1197192_0 | SOURCEANDSINK | GEN 1
Port_1197353_1 | SOURCEANDSINK | GEN 1
Port_1197192_1 | SOURCEANDSINK | GEN 1
Port_1197439_1 | SOURCEANDSINK | GEN 1
Port_1197256_0 | SOURCEANDSINK | GEN 1
Port_1197353_2 | SOURCEANDSINK | GEN 1
Port_1197256_1 | SOURCEANDSINK | GEN 1
Port_1197351_3 | SOURCEANDSINK | GEN 1
Port_1197351_2 | SOURCEANDSINK | GEN 1
Port_1197352_1 | SOURCEANDSINK | GEN 1
Port_1197429_0 | SOURCEANDSINK | GEN 1
Port_1197439_2 | SOURCEANDSINK | GEN 1
Port_1197429_1 | SOURCEANDSINK | GEN 1
Port_1197550_0 | SOURCEANDSINK | GEN 6
Port_1197566_1 | SOURCEANDSINK | GEN 6
Port_1197550_1 | SOURCEANDSINK | GEN 6
Port_1197561_0 | SOURCEANDSINK | GEN 6
Port_1197566_2 | SOURCEANDSINK | GEN 6
Port_1197561_1 | SOURCEANDSINK | GEN 6
Port_1197574_2 | SOURCEANDSINK | GEN 6
Port_1197567_0 | SOURCEANDSINK | GEN 6
Port_1197574_1 | SOURCEANDSINK | GEN 6
Port_1197567_1 | SOURCEANDSINK | GEN 6
Port_1197685_0 | SOURCEANDSINK | GEN 3
Port_1197977_1 | SOURCEANDSINK | GEN 3
Port_1197685_1 | SOURCEANDSINK | GEN 3
Port_1197686_0 | SOURCEANDSINK | GEN 3
Port_1197977_2 | SOURCEANDSINK | GEN 3
Port_1197686_1 | SOURCEANDSINK | GEN 3
Port_1197972_3 | SOURCEANDSINK | GEN 3
Port_1197755_0 | SOURCEANDSINK | GEN 3
Port_1198166_1 | SOURCEANDSINK | GEN 3
Port_1197755_1 | SOURCEANDSINK | GEN 3
Port_1197862_0 | SOURCEANDSINK | GEN 3
Port_1198261_1 | SOURCEANDSINK | GEN 3
Port_1197862_1 | SOURCEANDSINK | GEN 3
Port_1197972_1 | SOURCEANDSINK | GEN 3
Port_1197973_1 | SOURCEANDSINK | GEN 3
Port_1197973_0 | SOURCEANDSINK | GEN 3
Port_1198144_2 | SOURCEANDSINK | GEN 3
Port_1198115_0 | SOURCEANDSINK | GEN 3
Port_1198166_2 | SOURCEANDSINK | GEN 3
Port_1198115_1 | SOURCEANDSINK | GEN 3
Port_1198144_3 | SOURCEANDSINK | GEN 3
Port_1198144_1 | SOURCEANDSINK | GEN 3
Port_1198145_1 | SOURCEANDSINK | GEN 3
Port_1198216_0 | SOURCEANDSINK | GEN 3
Port_1198261_2 | SOURCEANDSINK | GEN 3
Port_1198216_1 | SOURCEANDSINK | GEN 3
Port_1198238_3 | SOURCEANDSINK | GEN 3
Port_1198238_1 | SOURCEANDSINK | GEN 3
Port_1198239_1 | SOURCEANDSINK | GEN 3
Port_1199947_0 | SOURCEANDSINK | EGA 1
Port_1200000_1 | SOURCEANDSINK | EGA 1
Port_1199947_1 | SOURCEANDSINK | EGA 1
Port_1200002_2 | SOURCEANDSINK | EGA 1
InPort_1200471_1 | SINK | S 4
OutPort_1200568_1 | SOURCE | S 4
InPort_1200513_0 | SINK | S 4
OutPort_1200564_2 | SOURCE | S 4
InPort_1200568_2 | SINK | S 4
OutPort_1200513_1 | SOURCE | S 4
InPort_1200564_1 | SINK | S 4
OutPort_1239700_0 | SOURCE | S 4
Port_1203614_0 | SOURCEANDSINK | FR 3
Port_1218851_1 | SOURCEANDSINK | FR 3
Port_1203614_1 | SOURCEANDSINK | FR 3
Port_1203936_2 | SOURCEANDSINK | FR 3
Port_1203779_0 | SOURCEANDSINK | FR 3
Port_1203871_2 | SOURCEANDSINK | FR 3
Port_1203779_1 | SOURCEANDSINK | FR 3
Port_1203781_0 | SOURCEANDSINK | FR 4
Port_1203875_2 | SOURCEANDSINK | FR 4
Port_1203781_1 | SOURCEANDSINK | FR 4
Port_1203783_0 | SOURCEANDSINK | FR 4
Port_1203877_2 | SOURCEANDSINK | FR 4
Port_1203783_1 | SOURCEANDSINK | FR 4
Port_1203785_0 | SOURCEANDSINK | FR 3
Port_1203879_2 | SOURCEANDSINK | FR 3
Port_1203785_1 | SOURCEANDSINK | FR 3
Port_1203826_0 | SOURCEANDSINK | FR 3
Port_1203924_1 | SOURCEANDSINK | FR 3
Port_1203826_1 | SOURCEANDSINK | FR 3
Port_1203871_1 | SOURCEANDSINK | FR 3
Port_1203828_0 | SOURCEANDSINK | FR 4
Port_1203875_1 | SOURCEANDSINK | FR 4
Port_1203828_1 | SOURCEANDSINK | FR 4
Port_1203959_1 | SOURCEANDSINK | FR 4
Port_1203830_0 | SOURCEANDSINK | FR 4
Port_1203998_1 | SOURCEANDSINK | FR 4
Port_1203830_1 | SOURCEANDSINK | FR 4
Port_1203877_1 | SOURCEANDSINK | FR 4
Port_1203832_0 | SOURCEANDSINK | FR 3
Port_1203879_1 | SOURCEANDSINK | FR 3
Port_1203832_1 | SOURCEANDSINK | FR 3
Port_1204035_1 | SOURCEANDSINK | FR 3
Port_1203922_0 | SOURCEANDSINK | FR 3
Port_1203924_2 | SOURCEANDSINK | FR 3
Port_1203922_1 | SOURCEANDSINK | FR 3
Port_1203936_1 | SOURCEANDSINK | FR 3
Port_1203957_0 | SOURCEANDSINK | FR 4
Port_1203959_2 | SOURCEANDSINK | FR 4
Port_1203957_1 | SOURCEANDSINK | FR 4
Port_1203971_1 | SOURCEANDSINK | FR 4
Port_1203971_2 | SOURCEANDSINK | FR 4
Port_1218864_0 | SOURCEANDSINK | FR 4
Port_1203996_0 | SOURCEANDSINK | FR 4
Port_1203998_2 | SOURCEANDSINK | FR 4
Port_1203996_1 | SOURCEANDSINK | FR 4
Port_1204010_1 | SOURCEANDSINK | FR 4
Port_1204010_2 | SOURCEANDSINK | FR 4
Port_1218911_0 | SOURCEANDSINK | FR 4
Port_1204033_0 | SOURCEANDSINK | FR 3
Port_1204035_2 | SOURCEANDSINK | FR 3
Port_1204033_1 | SOURCEANDSINK | FR 3
Port_1204047_1 | SOURCEANDSINK | FR 3
Port_1204047_2 | SOURCEANDSINK | FR 3
Port_1218956_0 | SOURCEANDSINK | FR 3
OutPort_1207384_0 | SOURCE | EU 10
InPort_1207384_1 | SINK | EU 10
OutPort_1222233_1 | SOURCE | EU 10
Port_1210963_0 | SOURCEANDSINK
Port_1210963_1 | SOURCEANDSINK
Port_1211018_2 | SOURCEANDSINK
Port_1210963_2 | SOURCEANDSINK
Port_1227951_0 | SOURCEANDSINK
Port_1210967_0 | SOURCEANDSINK
Port_1211018_1 | SOURCEANDSINK
Port_1210967_1 | SOURCEANDSINK
Port_1211019_2 | SOURCEANDSINK
Port_1211012_0 | SOURCEANDSINK
Port_1211013_2 | SOURCEANDSINK
Port_1211012_1 | SOURCEANDSINK
Port_1211019_1 | SOURCEANDSINK
Port_1211013_1 | SOURCEANDSINK
Port_1223199_0 | SOURCEANDSINK
Port_1211294_0 | SOURCEANDSINK | EU 2
Port_1224056_2 | SOURCEANDSINK | EU 2
InPort_1212784_1 | SINK | EV 4
OutPort_1212555_0 | SOURCE | EV 4
InPort_1212555_1 | SINK | EV 4
OutPort_1220772_1 | SOURCE | EV 4
InPort_1212784_2 | SINK | EV 4
OutPort_1212761_0 | SOURCE | EV 4
InPort_1212761_1 | SINK | EV 4
OutPort_1212980_1 | SOURCE | EV 4
Port_1212784_4 | SOURCEANDSINK | EV 4
Port_1212889_0 | SOURCEANDSINK | EV 4
Port_1212784_5 | SOURCEANDSINK | EV 4
Port_1212917_0 | SOURCEANDSINK | EV 4
Port_1212889_1 | SOURCEANDSINK | EV 4
Port_1212917_1 | SOURCEANDSINK | EV 4
InPort_1213433_0 | SINK | EU 9
OutPort_1213432_2 | SOURCE | EU 9
InPort_1213432_2 | SINK | EU 9
OutPort_1213433_0 | SOURCE | EU 9
InPort_1213433_1 | SINK | EU 9
OutPort_1221629_1 | SOURCE | EU 9
InPort_1213678_0 | SINK | EU 8
OutPort_1213677_2 | SOURCE | EU 8
InPort_1213677_2 | SINK | EU 8
OutPort_1213678_0 | SOURCE | EU 8
InPort_1213678_1 | SINK | EU 8
OutPort_1220308_1 | SOURCE | EU 8
Port_1214315_1 | SOURCEANDSINK
Port_1214325_1 | SOURCEANDSINK
InPort_1214626_0 | SINK | EU 7
OutPort_1221464_1 | SOURCE | EU 7
OutPort_1214626_1 | SOURCE | EU 7
Port_1215114_0 | SOURCEANDSINK | EF 1
Port_1225666_2 | SOURCEANDSINK | EF 1
Port_1215114_1 | SOURCEANDSINK | EF 1
Port_1215934_2 | SOURCEANDSINK | EF 1
Port_1215114_2 | SOURCEANDSINK | EF 1
Port_1225855_1 | SOURCEANDSINK | EF 1
Port_1215114_3 | SOURCEANDSINK | EF 1
Port_1225891_1 | SOURCEANDSINK | EF 1
Port_1215114_4 | SOURCEANDSINK | EF 1
Port_1225924_1 | SOURCEANDSINK | EF 1
Port_1215114_5 | SOURCEANDSINK | EF 1
Port_1225957_1 | SOURCEANDSINK | EF 1
Port_1215114_6 | SOURCEANDSINK | EF 1
Port_1226001_1 | SOURCEANDSINK | EF 1
Port_1215114_7 | SOURCEANDSINK | EF 1
Port_1226044_1 | SOURCEANDSINK | EF 1
InPort_1226076_1 | SINK | EF 1
OutPort_1215114_8 | SOURCE | EF 1
Port_1215133_0 | SOURCEANDSINK | EF 1
Port_1225851_1 | SOURCEANDSINK | EF 1
Port_1215133_1 | SOURCEANDSINK | EF 1
OutPort_1215239_1 | SOURCE
InPort_1215239_2 | SINK | EF 1
OutPort_1215240_0 | SOURCE | EF 1
InPort_1215240_1 | SINK | EF 1
OutPort_1215379_2 | SOURCE | EF 1
OutPort_1215276_1 | SOURCE
InPort_1215276_2 | SINK | EF 1
OutPort_1215277_1 | SOURCE | EF 1
InPort_1215277_0 | SINK | EF 1
OutPort_1215379_1 | SOURCE | EF 1
InPort_1226072_2 | SINK | EF 1
OutPort_1215300_0 | SOURCE | EF 1
InPort_1215300_1 | SINK | EF 1
OutPort_1226076_2 | SOURCE | EF 1
InPort_1215311_0 | SINK | EF 1
OutPort_1226072_1 | SOURCE | EF 1
InPort_1215379_3 | SINK | EF 1
OutPort_1215311_1 | SOURCE | EF 1
InPort_1215681_2 | SINK | EF 1
OutPort_1215605_0 | SOURCE | EF 1
InPort_1215605_1 | SINK | EF 1
OutPort_1215684_3 | SOURCE | EF 1
Port_1215678_0 | SOURCEANDSINK | EF 1
Port_1215684_1 | SOURCEANDSINK | EF 1
Port_1215678_1 | SOURCEANDSINK | EF 1
Port_1215716_1 | SOURCEANDSINK | EF 1
Port_1215684_2 | SOURCEANDSINK | EF 1
Port_1215685_0 | SOURCEANDSINK | EF 1
Port_1215685_1 | SOURCEANDSINK | EF 1
Port_1216122_1 | SOURCEANDSINK | EF 1
Port_1215708_0 | SOURCEANDSINK | EF 1
Port_1215716_2 | SOURCEANDSINK | EF 1
Port_1215708_1 | SOURCEANDSINK | EF 1
Port_1215992_1 | SOURCEANDSINK | EF 1
Port_1215833_0 | SOURCEANDSINK | EF 1
Port_1215942_2 | SOURCEANDSINK | EF 1
Port_1215833_1 | SOURCEANDSINK | EF 1
Port_1216005_1 | SOURCEANDSINK | EF 1
Port_1215934_3 | SOURCEANDSINK | EF 1
Port_1215942_1 | SOURCEANDSINK | EF 1
Port_1215945_0 | SOURCEANDSINK | EF 1
Port_1216005_2 | SOURCEANDSINK | EF 1
Port_1215945_1 | SOURCEANDSINK | EF 1
Port_1216009_2 | SOURCEANDSINK | EF 1
Port_1215990_0 | SOURCEANDSINK | EF 1
Port_1215992_2 | SOURCEANDSINK | EF 1
Port_1215990_1 | SOURCEANDSINK | EF 1
Port_1216009_1 | SOURCEANDSINK | EF 1
Port_1216114_0 | SOURCEANDSINK | EF 1
Port_1216122_2 | SOURCEANDSINK | EF 1
Port_1216114_1 | SOURCEANDSINK | EF 1
Port_1216131_2 | SOURCEANDSINK | EF 1
Port_1216125_0 | SOURCEANDSINK | EF 1
Port_1216131_1 | SOURCEANDSINK | EF 1
Port_1216125_1 | SOURCEANDSINK | EF 1
InPort_1216430_2 | SINK | S 1
OutPort_1216414_0 | SOURCE | S 1
InPort_1216414_1 | SINK | S 1
OutPort_1216440_1 | SOURCE | S 1
InPort_1216440_2 | SINK | S 1
OutPort_1216434_0 | SOURCE | S 1
InPort_1216434_1 | SINK | S 1
OutPort_1216452_1 | SOURCE | S 1
InPort_1216452_2 | SINK | S 1
OutPort_1216444_0 | SOURCE | S 1
InPort_1216444_1 | SINK | S 1
OutPort_1216466_1 | SOURCE | S 1
InPort_1216749_2 | SINK | VMC 2
OutPort_1216750_1 | SOURCE | VMC 2
InPort_1216772_0 | SINK | VMC 3
OutPort_1216771_1 | SOURCE | VMC 3
InPort_1217160_1 | SINK | VMC 3
OutPort_1216772_1 | SOURCE | VMC 3
InPort_1216774_0 | SINK | VMC 3
OutPort_1217160_2 | SOURCE | VMC 3
InPort_1217152_3 | SINK | VMC 2
OutPort_1216774_1 | SOURCE | VMC 2
InPort_1216916_0 | SINK | EU 3
OutPort_1218539_2 | SOURCE | EU 3
InPort_1221175_1 | SINK | EU 3
OutPort_1216916_1 | SOURCE | EU 3
InPort_1217152_2 | SINK | VMC 2
OutPort_1217153_1 | SOURCE | VMC 2
Port_1217510_2 | SOURCEANDSINK | FR 3
Port_1218173_0 | SOURCEANDSINK | FR 3
Port_1217628_1 | SOURCEANDSINK | FR 4
Port_1218208_0 | SOURCEANDSINK | FR 4
Port_1217681_1 | SOURCEANDSINK | FR 4
Port_1218259_0 | SOURCEANDSINK | FR 4
Port_1217754_1 | SOURCEANDSINK | FR 3
Port_1218292_0 | SOURCEANDSINK | FR 3
Port_1218173_1 | SOURCEANDSINK | FR 3
Port_1218189_2 | SOURCEANDSINK | FR 3
Port_1218181_0 | SOURCEANDSINK | FR 3
Port_1218189_1 | SOURCEANDSINK | FR 3
Port_1218181_1 | SOURCEANDSINK | FR 3
Port_1218198_0 | SOURCEANDSINK | FR 4
Port_1218198_1 | SOURCEANDSINK | FR 4
Port_1218216_1 | SOURCEANDSINK | FR 4
Port_1218208_1 | SOURCEANDSINK | FR 4
Port_1218216_2 | SOURCEANDSINK | FR 4
Port_1218259_1 | SOURCEANDSINK | FR 4
Port_1218273_2 | SOURCEANDSINK | FR 4
Port_1218265_0 | SOURCEANDSINK | FR 4
Port_1218273_1 | SOURCEANDSINK | FR 4
Port_1218265_1 | SOURCEANDSINK | FR 4
Port_1218281_1 | SOURCEANDSINK | FR 4
Port_1218275_0 | SOURCEANDSINK | FR 4
Port_1218281_2 | SOURCEANDSINK | FR 4
Port_1218275_1 | SOURCEANDSINK | FR 4
Port_1218292_1 | SOURCEANDSINK | FR 3
Port_1218310_2 | SOURCEANDSINK | FR 3
Port_1218300_0 | SOURCEANDSINK | FR 3
Port_1218310_1 | SOURCEANDSINK | FR 3
Port_1218300_1 | SOURCEANDSINK | FR 3
Port_1218320_1 | SOURCEANDSINK | FR 3
Port_1218312_0 | SOURCEANDSINK | FR 3
Port_1218320_2 | SOURCEANDSINK | FR 3
Port_1218312_1 | SOURCEANDSINK | FR 3
InPort_1218450_2 | SINK | EU 5
OutPort_1218446_0 | SOURCE | EU 5
InPort_1218446_1 | SINK | EU 5
OutPort_1222517_1 | SOURCE | EU 5
OutPort_1218448_0 | SOURCE | EU 18
InPort_1218448_1 | SINK | EU 18
OutPort_1218450_1 | SOURCE | EU 18
InPort_1218508_0 | SINK | EU 4
OutPort_1218519_2 | SOURCE | EU 4
InPort_1218512_1 | SINK | EU 4
OutPort_1218508_1 | SOURCE | EU 4
InPort_1218524_2 | SINK | EU 4
OutPort_1218510_0 | SOURCE | EU 4
InPort_1218510_1 | SINK | EU 4
OutPort_1218512_2 | SOURCE | EU 4
InPort_1218515_0 | SINK | EU 4
OutPort_1218539_1 | SOURCE | EU 4
InPort_1218519_1 | SINK | EU 4
OutPort_1218515_1 | SOURCE | EU 4
OutPort_1218517_0 | SOURCE | EU 4
InPort_1218517_1 | SINK | EU 4
OutPort_1218524_1 | SOURCE | EU 4
Port_1218819_0 | SOURCEANDSINK | FR 3
Port_1218847_2 | SOURCEANDSINK | FR 3
Port_1218819_1 | SOURCEANDSINK | FR 3
Port_1218851_2 | SOURCEANDSINK | FR 3
Port_1218864_1 | SOURCEANDSINK | FR 4
Port_1218881_1 | SOURCEANDSINK | FR 4
Port_1218872_0 | SOURCEANDSINK | FR 4
Port_1218881_2 | SOURCEANDSINK | FR 4
Port_1218872_1 | SOURCEANDSINK | FR 4
Port_1218902_1 | SOURCEANDSINK | FR 4
Port_1218884_0 | SOURCEANDSINK | FR 4
Port_1218898_2 | SOURCEANDSINK | FR 4
Port_1218884_1 | SOURCEANDSINK | FR 4
Port_1218902_2 | SOURCEANDSINK | FR 4
Port_1218911_1 | SOURCEANDSINK | FR 4
Port_1218927_1 | SOURCEANDSINK | FR 4
Port_1218921_0 | SOURCEANDSINK | FR 4
Port_1218927_2 | SOURCEANDSINK | FR 4
Port_1218921_1 | SOURCEANDSINK | FR 4
Port_1218947_1 | SOURCEANDSINK | FR 4
Port_1218930_0 | SOURCEANDSINK | FR 4
Port_1218943_2 | SOURCEANDSINK | FR 4
Port_1218930_1 | SOURCEANDSINK | FR 4
Port_1218947_2 | SOURCEANDSINK | FR 4
Port_1218956_1 | SOURCEANDSINK | FR 3
Port_1218970_1 | SOURCEANDSINK | FR 3
Port_1218964_0 | SOURCEANDSINK | FR 3
Port_1218970_2 | SOURCEANDSINK | FR 3
Port_1218964_1 | SOURCEANDSINK | FR 3
Port_1218993_1 | SOURCEANDSINK | FR 3
Port_1218973_0 | SOURCEANDSINK | FR 3
Port_1218986_2 | SOURCEANDSINK | FR 3
Port_1218973_1 | SOURCEANDSINK | FR 3
Port_1218993_2 | SOURCEANDSINK | FR 3
InPort_1219381_1 | SINK | U 2
OutPort_1219443_0 | SOURCE | U 2
InPort_1221620_1 | SINK | U 2
OutPort_1219381_2 | SOURCE | U 2
InPort_1219443_1 | SINK | U 2
OutPort_1219672_1 | SOURCE | U 2
InPort_1219672_2 | SINK | U 2
OutPort_1219632_0 | SOURCE | U 2
InPort_1219632_1 | SINK | U 2
OutPort_1219839_1 | SOURCE | U 2
InPort_1219839_2 | SINK | U 2
OutPort_1220118_0 | SOURCE | U 2
InPort_1220114_0 | SINK | U 2
OutPort_1222708_2 | SOURCE | U 2
InPort_1220120_2 | SINK | U 2
OutPort_1220114_1 | SOURCE | U 2
InPort_1220118_1 | SINK | U 2
OutPort_1220120_1 | SOURCE | U 2
InPort_1220308_2 | SINK | EU 8
OutPort_1220200_0 | SOURCE | EU 8
InPort_1220200_1 | SINK | EU 8
OutPort_1220313_3 | SOURCE | EU 8
InPort_1220558_0 | SINK | U 2
OutPort_1220313_1 | SOURCE | U 2
InPort_1220313_2 | SINK | U 2
OutPort_1220314_1 | SOURCE | U 2
InPort_1220314_0 | SINK | U 2
OutPort_1220331_1 | SOURCE | U 2
OutPort_1220371_0 | SOURCE | EU 6
InPort_1220371_1 | SINK | EU 6
OutPort_1220552_1 | SOURCE | EU 6
InPort_1220552_2 | SINK | EU 6
OutPort_1220382_0 | SOURCE | EU 6
InPort_1220382_1 | SINK | EU 6
OutPort_1220557_3 | SOURCE | EU 6
Port_1220557_1 | SOURCEANDSINK | U 2
Port_1220778_0 | SOURCEANDSINK | U 2
InPort_1220557_2 | SINK | U 2
OutPort_1220558_1 | SOURCE | U 2
Port_1220621_0 | SOURCEANDSINK | EU 19
Port_1220997_2 | SOURCEANDSINK | EU 19
Port_1220621_1 | SOURCEANDSINK | EU 19
Port_1221022_1 | SOURCEANDSINK | EU 19
Port_1220623_0 | SOURCEANDSINK | EU 19
Port_1223498_2 | SOURCEANDSINK | EU 19
Port_1220623_1 | SOURCEANDSINK | EU 19
InPort_1220772_2 | SINK | EV 4
OutPort_1220670_0 | SOURCE | EV 4
InPort_1220670_1 | SINK | EV 4
OutPort_1220935_5 | SOURCE | EV 4
Port_1220778_1 | SOURCEANDSINK | U 2
Port_1220935_2 | SOURCEANDSINK | U 2
Port_1220935_1 | SOURCEANDSINK | U 2
Port_1221469_0 | SOURCEANDSINK | U 2
Port_1220935_4 | SOURCEANDSINK | U 2
Port_1223591_0 | SOURCEANDSINK | U 2
Port_1220997_1 | SOURCEANDSINK | EU 19
Port_1223499_0 | SOURCEANDSINK | EU 19
Port_1221009_0 | SOURCEANDSINK | EU 19
Port_1221022_2 | SOURCEANDSINK | EU 19
Port_1221009_1 | SOURCEANDSINK | EU 19
Port_1223569_1 | SOURCEANDSINK | EU 19
Port_1221026_0 | SOURCEANDSINK | EU 19
Port_1223569_2 | SOURCEANDSINK | EU 19
Port_1221026_1 | SOURCEANDSINK | EU 19
OutPort_1221175_2 | SOURCE | EU 3
InPort_1221464_2 | SINK | EU 7
OutPort_1221246_0 | SOURCE | EU 7
InPort_1221246_1 | SINK | EU 7
OutPort_1221468_3 | SOURCE | EU 7
Port_1221468_1 | SOURCEANDSINK | U 2
Port_1226898_0 | SOURCEANDSINK | U 2
Port_1221468_2 | SOURCEANDSINK | U 2
Port_1221469_1 | SOURCEANDSINK | U 2
InPort_1221629_2 | SINK | EU 9
OutPort_1221517_0 | SOURCE | EU 9
InPort_1221517_1 | SINK | EU 9
OutPort_1221633_3 | SOURCE | EU 9
InPort_1221633_1 | SINK | U 2
OutPort_1221620_0 | SOURCE | U 2
Port_1221633_2 | SOURCEANDSINK | U 2
Port_1221634_1 | SOURCEANDSINK | U 2
Port_1221634_0 | SOURCEANDSINK | U 2
Port_1226897_2 | SOURCEANDSINK | U 2
InPort_1221851_2 | SINK | U 1
OutPort_1221845_0 | SOURCE | U 1
InPort_1221845_1 | SINK | U 1
OutPort_1222053_1 | SOURCE | U 1
InPort_1222073_1 | SINK | U 1
OutPort_1221847_0 | SOURCE | U 1
InPort_1221847_1 | SINK | U 1
OutPort_1224052_1 | SOURCE | U 1
InPort_1222510_1 | SINK | U 1
OutPort_1221851_1 | SOURCE | U 1
InPort_1222069_2 | SINK | U 1
OutPort_1221940_0 | SOURCE | U 1
InPort_1221940_1 | SINK | U 1
OutPort_1222073_2 | SOURCE | U 1
InPort_1222053_2 | SINK | U 1
OutPort_1222042_0 | SOURCE | U 1
InPort_1222042_1 | SINK | U 1
OutPort_1222069_1 | SOURCE | U 1
InPort_1222233_2 | SINK | EU 10
OutPort_1222110_0 | SOURCE | EU 10
InPort_1222110_1 | SINK | EU 10
OutPort_1222237_3 | SOURCE | EU 10
InPort_1222237_1 | SINK | U 1
OutPort_1222345_0 | SOURCE | U 1
InPort_1222238_1 | SINK | U 1
OutPort_1222237_2 | SOURCE | U 1
OutPort_1222238_0 | SOURCE | U 1
OutPort_1222266_0 | SOURCE | EV 2
InPort_1222266_1 | SINK | EV 2
OutPort_1222339_1 | SOURCE | EV 2
InPort_1222339_2 | SINK | EV 2
OutPort_1222274_0 | SOURCE | EV 2
InPort_1222274_1 | SINK | EV 2
OutPort_1222344_3 | SOURCE | EV 2
InPort_1222344_1 | SINK | U 1
OutPort_1222523_0 | SOURCE | U 1
InPort_1222345_1 | SINK | U 1
OutPort_1222344_2 | SOURCE | U 1
InPort_1222517_2 | SINK | EU 5
OutPort_1222375_0 | SOURCE | EU 5
InPort_1222375_1 | SINK | EU 5
OutPort_1222522_3 | SOURCE | EU 5
InPort_1222522_1 | SINK | U 1
OutPort_1222510_0 | SOURCE | U 1
InPort_1222523_1 | SINK | U 1
OutPort_1222522_2 | SOURCE | U 1
InPort_1222725_2 | SINK | EU 11
OutPort_1222649_0 | SOURCE | EU 11
InPort_1222649_1 | SINK | EU 11
OutPort_1222729_2 | SOURCE | EU 11
OutPort_1222651_0 | SOURCE | EU 11
InPort_1222651_1 | SINK | EU 11
OutPort_1222725_1 | SOURCE | EU 11
InPort_1222706_0 | SINK | EU 11
OutPort_1222708_3 | SOURCE | EU 11
InPort_1222729_1 | SINK | EU 11
OutPort_1222706_1 | SOURCE | EU 11
InPort_1222708_1 | SINK | U 2
OutPort_1222709_0 | SOURCE | U 2
InPort_1222709_1 | SINK | U 2
OutPort_1223915_1 | SOURCE | U 2
Port_1222838_0 | SOURCEANDSINK | EF 1
Port_1222968_2 | SOURCEANDSINK | EF 1
Port_1222838_1 | SOURCEANDSINK | EF 1
Port_1228281_2 | SOURCEANDSINK | EF 1
Port_1223159_0 | SOURCEANDSINK
Port_1223210_2 | SOURCEANDSINK
Port_1223159_1 | SOURCEANDSINK
Port_1223212_2 | SOURCEANDSINK
Port_1223199_1 | SOURCEANDSINK
Port_1223201_1 | SOURCEANDSINK
Port_1223200_0 | SOURCEANDSINK
Port_1223201_2 | SOURCEANDSINK
Port_1223200_1 | SOURCEANDSINK
Port_1223212_1 | SOURCEANDSINK
Port_1223405_0 | SOURCEANDSINK | EU 19
Port_1223504_1 | SOURCEANDSINK | EU 19
Port_1223405_1 | SOURCEANDSINK | EU 19
Port_1223475_0 | SOURCEANDSINK | EU 19
Port_1223498_3 | SOURCEANDSINK | EU 19
Port_1223475_1 | SOURCEANDSINK | EU 19
Port_1223504_2 | SOURCEANDSINK | EU 19
Port_1223498_1 | SOURCEANDSINK | EU 19
Port_1223499_1 | SOURCEANDSINK | EU 19
Port_1223591_1 | SOURCEANDSINK | U 2
Port_1223631_1 | SOURCEANDSINK | U 2
Port_1223631_2 | SOURCEANDSINK | U 2
InPort_1223915_2 | SINK | U 2
OutPort_1223858_0 | SOURCE | U 2
InPort_1223925_2 | SINK | EU 2
OutPort_1223858_1 | SOURCE | EU 2
Port_1223919_1 | SOURCEANDSINK | EU 2
Port_1223920_1 | SOURCEANDSINK | EU 2
Port_1223919_2 | SOURCEANDSINK | EU 2
Port_1224057_0 | SOURCEANDSINK | EU 2
InPort_1223919_3 | SINK | EU 2
OutPort_1223925_1 | SOURCE | EU 2
InPort_1224052_2 | SINK | U 1
OutPort_1223987_0 | SOURCE | U 1
InPort_1223987_1 | SINK | U 1
OutPort_1224062_2 | SOURCE | U 1
Port_1224056_1 | SOURCEANDSINK | EU 2
Port_1224057_1 | SOURCEANDSINK | EU 2
InPort_1224056_3 | SINK | EU 2
OutPort_1224062_1 | SOURCE | EU 2
Port_1225241_0 | SOURCEANDSINK | EF 1
Port_1225997_1 | SOURCEANDSINK | EF 1
Port_1225241_1 | SOURCEANDSINK | EF 1
Port_1225260_2 | SOURCEANDSINK | EF 1
Port_1225260_1 | SOURCEANDSINK | EF 1
Port_1225347_0 | SOURCEANDSINK | EF 1
Port_1225269_0 | SOURCEANDSINK | EF 1
Port_1226040_1 | SOURCEANDSINK | EF 1
Port_1225269_1 | SOURCEANDSINK | EF 1
Port_1225293_1 | SOURCEANDSINK | EF 1
Port_1225282_0 | SOURCEANDSINK | EF 1
Port_1225293_2 | SOURCEANDSINK | EF 1
Port_1225282_1 | SOURCEANDSINK | EF 1
Port_1225347_1 | SOURCEANDSINK | EF 1
Port_1225363_1 | SOURCEANDSINK | EF 1
Port_1225355_0 | SOURCEANDSINK | EF 1
Port_1225363_2 | SOURCEANDSINK | EF 1
Port_1225355_1 | SOURCEANDSINK | EF 1
Port_1225371_1 | SOURCEANDSINK | EF 1
Port_1225365_0 | SOURCEANDSINK | EF 1
Port_1225371_2 | SOURCEANDSINK | EF 1
Port_1225365_1 | SOURCEANDSINK | EF 1
Port_1225399_0 | SOURCEANDSINK | EF 1
Port_1225997_2 | SOURCEANDSINK | EF 1
Port_1225399_1 | SOURCEANDSINK | EF 1
Port_1226001_2 | SOURCEANDSINK | EF 1
Port_1225503_0 | SOURCEANDSINK | EF 1
Port_1226040_2 | SOURCEANDSINK | EF 1
Port_1225503_1 | SOURCEANDSINK | EF 1
Port_1226044_2 | SOURCEANDSINK | EF 1
Port_1226707_0 | SOURCEANDSINK | EF 3
Port_1226711_2 | SOURCEANDSINK | EF 3
Port_1226707_1 | SOURCEANDSINK | EF 3
Port_1226709_0 | SOURCEANDSINK | EF 3
Port_1226711_1 | SOURCEANDSINK | EF 3
Port_1226709_1 | SOURCEANDSINK | EF 3
Port_1226754_1 | SOURCEANDSINK | EF 3
Port_1226744_0 | SOURCEANDSINK | EF 3
Port_1226754_2 | SOURCEANDSINK | EF 3
Port_1226744_1 | SOURCEANDSINK | EF 3
Port_1226788_1 | SOURCEANDSINK | EF 3
Port_1226780_0 | SOURCEANDSINK | EF 3
Port_1226788_2 | SOURCEANDSINK | EF 3
Port_1226780_1 | SOURCEANDSINK | EF 3
InPort_1226863_2 | SINK | EU 16
OutPort_1226859_0 | SOURCE | EU 16
InPort_1226859_1 | SINK | EU 16
OutPort_1226909_1 | SOURCE | EU 16
OutPort_1226861_0 | SOURCE | EU 16
InPort_1226861_1 | SINK | EU 16
OutPort_1226863_1 | SOURCE | EU 16
InPort_1226874_0 | SINK | EU 16
OutPort_1226897_3 | SOURCE | EU 16
InPort_1226909_2 | SINK | EU 16
OutPort_1226874_1 | SOURCE | EU 16
Port_1226897_1 | SOURCEANDSINK | U 2
Port_1226898_1 | SOURCEANDSINK | U 2
Port_1227951_1 | SOURCEANDSINK
Port_1227953_1 | SOURCEANDSINK
Port_1227952_0 | SOURCEANDSINK
Port_1227953_2 | SOURCEANDSINK
Port_1227952_1 | SOURCEANDSINK
Port_1227964_1 | SOURCEANDSINK
Port_1228008_1 | SOURCEANDSINK
Port_1228036_1 | SOURCEANDSINK
Port_1228044_1 | SOURCEANDSINK
Port_1228122_1 | SOURCEANDSINK
Port_1228123_1 | SOURCEANDSINK
Port_1228147_1 | SOURCEANDSINK
Port_1228148_1 | SOURCEANDSINK
Port_1228180_1 | SOURCEANDSINK
Port_1228207_1 | SOURCEANDSINK
Port_1228237_1 | SOURCEANDSINK
Port_1228238_1 | SOURCEANDSINK
Port_1228258_1 | SOURCEANDSINK
Port_1228259_1 | SOURCEANDSINK
Port_1228273_0 | SOURCEANDSINK | EF 1
Port_1228275_2 | SOURCEANDSINK | EF 1
Port_1228273_1 | SOURCEANDSINK | EF 1
Port_1228277_1 | SOURCEANDSINK | EF 1
InPort_1228922_1 | SINK | S 1
OutPort_1228961_1 | SOURCE | S 1
Port_1229332_0 | SOURCEANDSINK | EGA 1
Port_1229332_1 | SOURCEANDSINK | EGA 1
Port_1229352_2 | SOURCEANDSINK | EGA 1
Port_1229344_0 | SOURCEANDSINK | EGA 1
Port_1229352_1 | SOURCEANDSINK | EGA 1
Port_1229344_1 | SOURCEANDSINK | EGA 1
Port_1229404_1 | SOURCEANDSINK | EGA 1
Port_1229354_0 | SOURCEANDSINK | EGA 1
Port_1229404_2 | SOURCEANDSINK | EGA 1
Port_1229354_1 | SOURCEANDSINK | EGA 1
Port_1229406_3 | SOURCEANDSINK | EGA 1
Port_1229399_0 | SOURCEANDSINK | EGA 1
Port_1229406_1 | SOURCEANDSINK | EGA 1
Port_1229406_2 | SOURCEANDSINK | EGA 1
Port_1229407_1 | SOURCEANDSINK | EGA 1
Port_1229428_0 | SOURCEANDSINK | EGA 1
Port_1229430_2 | SOURCEANDSINK | EGA 1
Port_1229428_1 | SOURCEANDSINK | EGA 1
Port_1229432_3 | SOURCEANDSINK | EGA 1
Port_1229430_1 | SOURCEANDSINK | EGA 1
Port_1229609_0 | SOURCEANDSINK | EGA 1
Port_1229432_1 | SOURCEANDSINK | EGA 1
Port_1229481_1 | SOURCEANDSINK | EGA 1
Port_1229481_0 | SOURCEANDSINK | EGA 1
Port_1229499_1 | SOURCEANDSINK | EGA 1
Port_1229552_0 | SOURCEANDSINK | EGA 1
Port_1229552_1 | SOURCEANDSINK | EGA 1
Port_1229570_2 | SOURCEANDSINK | EGA 1
Port_1229560_0 | SOURCEANDSINK | EGA 1
Port_1229570_1 | SOURCEANDSINK | EGA 1
Port_1229560_1 | SOURCEANDSINK | EGA 1
Port_1229621_1 | SOURCEANDSINK | EGA 1
Port_1229572_0 | SOURCEANDSINK | EGA 1
Port_1229621_2 | SOURCEANDSINK | EGA 1
Port_1229572_1 | SOURCEANDSINK | EGA 1
Port_1229623_2 | SOURCEANDSINK | EGA 1
Port_1229609_1 | SOURCEANDSINK | EGA 1
Port_1229613_1 | SOURCEANDSINK | EGA 1
Port_1229610_0 | SOURCEANDSINK | EGA 1
Port_1229613_2 | SOURCEANDSINK | EGA 1
Port_1229610_1 | SOURCEANDSINK | EGA 1
Port_1229623_1 | SOURCEANDSINK | EGA 1
Port_1234153_1 | SOURCEANDSINK
Port_1234173_1 | SOURCEANDSINK
Port_1234189_1 | SOURCEANDSINK
Port_1234220_1 | SOURCEANDSINK
Port_1234528_1 | SOURCEANDSINK
InPort_1237861_1 | SINK | EC 1
OutPort_1237825_1 | SOURCE | EC 1
InPort_1237851_0 | SINK | EC 1
OutPort_1237861_2 | SOURCE | EC 1
InPort_1237878_1 | SINK | EC 1
OutPort_1237851_1 | SOURCE | EC 1
InPort_1239700_1 | SINK | S 4
OutPort_1239698_1 | SOURCE | S 4
Port_1239698_3 | SOURCEANDSINK
Port_1241667_1 | SOURCEANDSINK
Port_1241693_1 | SOURCEANDSINK
Port_1241747_1 | SOURCEANDSINK
Port_1241929_1 | SOURCEANDSINK
OutPort_1241929_2 | SOURCE
Port_1241929_3 | SOURCEANDSINK
Port_1241929_4 | SOURCEANDSINK
InPort_1241929_5 | SINK
InPort_1241929_6 | SINK
Port_1242392_1 | SOURCEANDSINK

# IfcEnergyConversionDevice: AI_Eqpmt genie clim_Cassette 1 voie Mitsubishi Electric_PMFY-P-VBM_INT-EN:PMFY-P20VBM-E (6)
In: RDC
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 164-172-174, Color RGB 245-245-245, Color RGB 200-200-200, Color RGB 187-080-046, Color RGB 117-117-117
Type - Autre - Catégorie: Equipement de génie climatique; Fan Quantity: 1; Fan Type: Line flow; Nom de la famille: AI_Eqpmt genie clim_Cassette 1 voie Mitsubishi Electric_PMFY-P-VBM_INT-EN; Refrigerant Type: R410A
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Depth: 395 mm; Drain Diameter: 32 mm; Height: 230 mm; Refrigerant Gas Diameter: 12.7 mm; Refrigerant Liquid Diameter: 6.35 mm; Supply Air Diameter: 100 mm; Width: 812 mm
Type - Electrique - Hertz: 50 Hz; Phase: 1; Voltage: 240.002 V
Type - Données d'identification - Article Description: 1-way blow ceiling cassette indoor unit; Article Type: PMFY-P20VBM-E; Base Family Version: 25.06; Content Supplier URL: www.MEPcontent.com; Copyright: ©Mitsubishi Electric Corporation / Trimble Europe BV; Custom: no; Description: 1-way blow ceiling cassette indoor unit; EMCS Version: 4.0; ETIM Article Class: EC000403; Fabricant: Mitsubishi Electric Corporation; Family Version: 11.21; Manufacturer Art. No.: PMFY-P20VBM-E; Manufacturer URL: http://www.mitsubishielectric.com/; MEPcontent Class: AIR_CONDITIONER_INDOOR_UNIT; Modèle: PMFY-P20VBM-E; Nom du type: PMFY-P20VBM-E; Numéro OmniClass: 23.75.10.24.21.27; Product Line: City Multi PMFY-P-VBM-E; Revit Version: 2023; Sous-projet: Famille : Equipement de génie climatique : AI_Eqpmt genie clim_Cassette 1 voie Mitsubishi Electric_PMFY-P-VBM_INT-EN; Titre OmniClass: Unitary Air Conditioning Equipment; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Génie climatique - Classification: Aucun
Type - Génie climatique - Charges - Airflow Rate (m3/min): 8.7; Cooling Capacity (kW): 2.2; Cooling Current (A): 0.2; Cooling Power Input (kW): 0.042; External Static Pressure (Pa): 0; Fan Motor Output (kW): 0.028; Heating Capacity (kW): 2.5; Heating Current (A): 0.2; Heating Power Input (kW): 0.042; Sound Pressure Level (dB(A)): 35; Unit Weight (kg): 14
Type - Pset_ManufacturerTypeInformation - Manufacturer: Mitsubishi Electric Corporation
Pset_DistributionFlowElementCommon - Reference: PMFY-P20VBM-E; sets with these values: 2
Autre - Famille: AI_Eqpmt genie clim_Cassette 1 voie Mitsubishi Electric_PMFY-P-VBM_INT-EN; Famille et type: AI_Eqpmt genie clim_Cassette 1 voie Mitsubishi Electric_PMFY-P-VBM_INT-EN: PMFY-P20VBM-E; ID du type: 859940; Offset From Ceiling: 0 mm; Offset Start: -112.3 mm; Service Offset: 0 mm; Type: PMFY-P20VBM-E
Contraintes - Niveau: RDC; Décalage par rapport à l'hôte: 2702.44 mm; Élévation par rapport au niveau: 2702.44 mm; Hôte: Niveau : RDC
Cotes - Ceiling Offset: 0 mm; Surface: 2.76801 m2; Volume: 0.375497 m3
Electrique - Power: 0 W
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Classification du système: Puissance,Sanitaire,Alimentation hydraulique,Soufflage; Drain Fixture Units: 0; Flow Refrigerant Gas: 0 m3/s; Flow Refrigerant Liquid: 0 m3/s
Génie climatique - Débit - Supply Air Flow 1: 0 m3/s; Supply Air Flow 2: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
Visibilité - Service Space: no
Name (AI_Eqpmt genie clim_Cassette 1 voie Mitsubishi Electric_PMFY-P-VBM_INT-EN:PMFY-P20VBM-E:...) | Commentaires | Identifiant
859962 | 1,9 kWf | 18
861206 | 1,9 kWf | 19
861223 | 3,6 kWf | 20
861234 | 3,5 kWf | 21
861245 | 3,6 kWf | 22
1241929 | 3,6 kWf | 60 | Données d'identification - Modifié par: christophe.sautron

# IfcFlowController: AI_Acc canalisation_Calculateur d'énergie:Commande murale Clim, AI_Acc canalisation_Calculateur d'énergie:Commande murale Clim:963232
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Accessoire de canalisation; Nom de la famille: AI_Acc canalisation_Calculateur d'énergie
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - AI_Hauteur Equipement: 175 mm; AI_Largeur Equipement: 110 mm; AI_Longueur Equipement: 150 mm
Type - Données d'identification - Nom du type: Commande murale Clim; Sous-projet: Famille : Accessoire de canalisation : AI_Acc canalisation_Calculateur d'énergie
Pset_DistributionFlowElementCommon - Reference: Commande murale Clim; sets with these values: 2
Autre - Type: Commande murale Clim; Famille: AI_Acc canalisation_Calculateur d'énergie; Famille et type: AI_Acc canalisation_Calculateur d'énergie: Commande murale Clim; ID du type: 963164
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 2851.88 mm
Cotes - Surface: 0.0749406 m2; Volume: 0.00293707 m3
Graphismes - Utiliser l'échelle d'annotations: no
Données d'identification - Sous-projet: 01_CVC; Identifiant: 10
Génie climatique - Classification du système: Communication
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm

# IfcFlowController: AI_Acc canalisation_Compteur d'eau:DN32, AI_Acc canalisation_Compteur d'eau:DN32:956237
In: RDC
Type - Material: Color RGB 055-055-055, Color RGB 000-000-220, Color RGB 220-220-220
Type - Autre - Catégorie: Accessoire de canalisation; Blend Void Length: 14.25 mm; Diameter 1: 28.4 mm; Length 1: 13.45 mm; Nom de la famille: AI_Acc canalisation_Compteur d'eau; Reference Flow Formula Number: 10; Right End: 52.5 mm; Symbol Position: 5 mm
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Use Nominal Diameter: yes; Connection Diameter: 32 mm; Connection Nominal Diameter: 32 mm; Connection Outer Diameter: 26.9 mm; Diameter: 91.5989 mm; Height: 59.9993 mm; Length: 110 mm
Type - Données d'identification - Custom: no; Article Description: Cold water flow meter; Article Type: 2.5XG1BX105; Content Supplier URL: www.mepcontent.eu; Copyright: © Stabiplan International BV; Description: Cold water flow meter; EMCS Version: 2.0; ETIM Article Class: EC010586; Fabricant: Kamstrup; Family Version: 10.14; Manufacturer Art. No.: 021-XX-C0G8XX; Manufacturer URL: http://products.kamstrup.com/ajax/downloadFile.php?uid=55d2eeb58f1cc&display=1; MEPcontent Class: METER_WATER; Modèle: 2.5XG1BX105; Nom du type: DN32; Numéro OmniClass: 23.60.10.17; Product Line: Kamstrup; Revit Version: 2015; Sous-projet: Famille : Accessoire de canalisation : AI_Acc canalisation_Compteur d'eau; Titre OmniClass: Flow Meters; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Matériaux et finitions - Black: Color RGB 055-055-055; Blue: Color RGB 000-000-220; White: Color RGB 220-220-220
Type - Génie climatique - Pressure Stage: 0 Pa
Type - Génie climatique - Débit - Maximum Volume Flow: 0.00086 m3/s; Minimum Volume Flow: 0.00000277778 m3/s; Nominal Volume Flow: 0.00069 m3/s; Reference Flow: 0.001 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kamstrup
Pset_DistributionFlowElementCommon - Reference: DN32; sets with these values: 2
Autre - Famille: AI_Acc canalisation_Compteur d'eau; Famille et type: AI_Acc canalisation_Compteur d'eau: DN32; ID du type: 956131; Type: DN32
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 2918.3 mm
Cotes - Taille: 32 mmø-32 mmø; Taille maximale: 32 mm; Taille minimale: 32 mm; Volume: 0.000399515 m3
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 01_CVC; Identifiant: 5
Génie climatique - Type de système: 0.Eau Glacée Aller; Abréviation du système: EGA; Classification du système: Eau froide sanitaire; Nom du système: EGA 1
Génie climatique - Débit - Trajectoire critique: no; Flow In: 0 m3/s; Flow Out: 0 m3/s; Ignorer l'analyse du débit: no; Perte de pression: 0 Pa
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø-32 mmø
Group: EGA 1

# IfcFlowController: AI_Acc canalisation_Robinet à tournant sphérique - 8-100 mm - Fileté - Laiton:32 mm (4)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Accessoire de canalisation; Diamètre de l'adaptateur: 35.2 mm; Diamètre de l'écrou: 20.8 mm; Hauteur 1: 12.5 mm; Hauteur 2: 3.69318 mm; Hauteur 3: 1.875 mm; Hauteur 4: 3 mm; Hauteur de l'adaptateur: 12.4451 mm; Hauteur de l'écrou: 40.625 mm; Ligne du symbole: 55.4256 mm; Ligne du symbole 1: 11.3137 mm; Longueur: 13.4705 mm; Longueur 1: 4.368 mm; Longueur 2: 19.775 mm; Longueur 3: 15.6 mm; Longueur de l'adaptateur: 15.6 mm; Longueur du corps 1: 6.5 mm; Longueur du corps 2: 3.25 mm; Nom de la famille: AI_Acc canalisation_Robinet à tournant sphérique - 8-100 mm - Fileté - Laiton; Rayon 1: 6.24 mm; Rayon 2: 14.56 mm; Rayon 3: 5.2 mm; Rayon de l'adaptateur: 17.6 mm; Rayon de l'écrou: 10.4 mm; Rayon du corps 1: 21.6 mm; Rayon du corps 2: 20.8 mm; Rayon du corps 3: 17.6 mm; Rayon du corps 4: 16.48 mm; Rayon du corps 5: 0 mm; Rayon du symbole: 8 mm
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - A: 105 mm; Diamètre nominal: 32 mm; H: 62.5 mm; L: 78 mm; Rayon nominal: 16 mm
Type - Données d'identification - Nom du type: 32 mm; Poids: 0.589 kg; Sous-projet: Famille : Accessoire de canalisation : AI_Acc canalisation_Robinet à tournant sphérique - 8-100 mm - Fileté - Laiton
Type - Génie climatique - Méthode de perte de charge: Coefficient K à partir du tableau; Pression nominale: 2500000 Pa; Tableau de coefficient K: Robinets à tournant sphérique - Passage intégral - Ouverture complète; Température maximale: 30 C
Pset_DistributionFlowElementCommon - Reference: 32 mm; sets with these values: 2
Autre - Famille: AI_Acc canalisation_Robinet à tournant sphérique - 8-100 mm - Fileté - Laiton; Famille et type: AI_Acc canalisation_Robinet à tournant sphérique - 8-100 mm - Fileté - Laiton: 32 mm; ID du type: 969602; Type: 32 mm
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 2918.3 mm
Cotes - Taille: 32 mmø-32 mmø; Taille maximale: 32 mm; Taille minimale: 32 mm; Volume: 0.0000992992 m3
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Type de système: 0.Eau Glacée Aller; Abréviation du système: EGA; Classification du système: Alimentation hydraulique; Nom du système: EGA 1
Génie climatique - Débit - Trajectoire critique: no; Ignorer l'analyse du débit: no; Perte de pression: 0 Pa
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø-32 mmø
Group: EGA 1
Name (AI_Acc canalisation_Robinet à tournant sphérique - 8-100 mm - Fileté - Laiton:32 mm:...) | Identifiant
969645 | 11
969661 | 12
1195130 | 13
1195150 | 14

# IfcFlowController: AI_Acc canalisation_Sonde de température:AI_Acc canalisation_Sonde de température (2)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Accessoire de canalisation; Nom de la famille: AI_Acc canalisation_Sonde de température; Offset: 0 mm
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Sensor Length: 100 mm
Type - Données d'identification - Nom du type: AI_Acc canalisation_Sonde de température; Sous-projet: Famille : Accessoire de canalisation : AI_Acc canalisation_Sonde de température
Pset_DistributionFlowElementCommon - Reference: AI_Acc canalisation_Sonde de température; sets with these values: 2
Autre - Famille: AI_Acc canalisation_Sonde de température; Famille et type: AI_Acc canalisation_Sonde de température: AI_Acc canalisation_Sonde de température; ID du type: 962170; Type: AI_Acc canalisation_Sonde de température
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 2918.3 mm
Cotes - Surface: 0.0110335 m2; Taille: 32 mmø; Taille maximale: 32 mm; Taille minimale: 32 mm; Volume: 0.000146046 m3
Données d'identification - Sous-projet: 01_CVC
Génie climatique - Type de système: 0.Eau Glacée Aller; Abréviation du système: EGA; Classification du système: Alimentation hydraulique
Génie climatique - Débit - Trajectoire critique: no; Ignorer l'analyse du débit: no; Perte de pression: 0 Pa
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø
Name (AI_Acc canalisation_Sonde de température:AI_Acc canalisation_Sonde de température:...) | Identifiant | Nom du système = Group
962187 | 7 | EGA 3
962234 | 9 | EGA 4

# IfcFlowController: AI_Acc canalisation_Vanne d'arrêt équipement murale:DN 20 (3)
In: RDC
Type - Material: Color RGB 187-185-183, <Unnamed>
Type - Autre - Catégorie: Accessoire de canalisation; Array: 9; Connection Length: 49 mm; Domestic Cold Water Connection Diameter 1: 20 mm; Domestic Cold Water Connection Diameter 2: 20 mm; Inner Radius: 11.818 mm; L1: 5 mm; L10: 18.305 mm; L2: 8 mm; L3: 4.6 mm; L4: 2.4 mm; L5: 26.6 mm; L6: 26.4 mm; L6A: 2 mm; L6B: 4.8 mm; L7: 18.632 mm; L8: 19 mm; L9: 19.014 mm; Nom de la famille: AI_Acc canalisation_Vanne d'arrêt équipement murale; R3: 10 mm; R4: 3.5 mm; R5: 9 mm; R6: 12.8 mm; R6A: 10.8 mm; R6B: 9.891 mm; R7: 5 mm; R8: 9.30055 mm
Type - Contraintes - Elévation par défaut: 1219.2 mm
Type - Cotes - Length: 90 mm; Use Nominal Diameter: yes
Type - Données d'identification - Custom: no; Article Description: Regulating angle valve; Article Type: DN 20; Content Supplier URL: www.mepcontent.eu; Copyright: © Stabiplan International BV; Description: Regulating angle valve; EMCS Version: 3.0; ETIM Article Class: EC010120; Family Version: 11.02; MEPcontent Class: VALVE_ANGLE_REGULATING; Modèle: DN 20; Nom du type: DN 20; Numéro OmniClass: 23.65.55.14; Revit Version: 2016; Sous-projet: Famille : Accessoire de canalisation : AI_Acc canalisation_Vanne d'arrêt équipement murale; Titre OmniClass: Valves for Liquid Services; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Matériaux et finitions - Chrome: Color RGB 187-185-183
Type - Génie climatique - Domestic Cold Water Flow 1: 0 m3/s; Domestic Cold Water Flow 2: 0 m3/s; Zeta Value: 0
Pset_DistributionFlowElementCommon - Reference: DN 20; sets with these values: 2
Autre - Famille: AI_Acc canalisation_Vanne d'arrêt équipement murale; Famille et type: AI_Acc canalisation_Vanne d'arrêt équipement murale: DN 20; ID du type: 935377; Type: DN 20
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 550.694 mm; Niveau de nomenclature: RDC; Plan de construction: Niveau : RDC
Cotes - Taille: 20 mmø-20 mmø; Taille maximale: 20 mm; Taille minimale: 20 mm; Volume: 0.0000525106 m3
Graphismes - Utiliser l'échelle d'annotations: yes; Annotation Offset: 0 mm
Données d'identification - Sous-projet: 03_PLB
Génie climatique - Abréviation du système: EF; Classification du système: Eau froide sanitaire; Nom du système: EF 1; Type de système: 2.Eau Froide Sanitaire
Génie climatique - Débit - Perte de pression: 0 Pa
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 20 mmø-20 mmø
Group: EF 1
Name (AI_Acc canalisation_Vanne d'arrêt équipement murale:DN 20:...) | Identifiant
938843 | 3
1215239 | 15
1215276 | 16

# IfcFlowFitting: AI_Racc cana_Transformation Generique:Standard, AI_Racc cana_Transformation Generique:Standard:1215942
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de canalisation; Nom de la famille: AI_Racc cana_Transformation Generique; Nom de la table de consultation: M_Pipe Fitting - Generic
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: Standard; Numéro OmniClass: 23.60.30.11.14; Sous-projet: Famille : Raccords de canalisation : AI_Racc cana_Transformation Generique; Titre OmniClass: Pipework Fittings
Type - Génie climatique - Méthode de perte de charge: Coefficient K à partir du tableau; Tableau de coefficient K: Réduction/Manchon/Union/Augmentation
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Autre - Type: Standard; Visibilité 3: no; Décalage de la hauteur: 3048 mm; Décalage de la largeur: 3048 mm; Diamètre extérieur max. du raccord 12: 28.575 mm; Famille: AI_Racc cana_Transformation Generique; Famille et type: AI_Racc cana_Transformation Generique: Standard; ID du type: 805329; Rayon extérieur du raccord 1: 14.2875 mm; Rayon extérieur du raccord 2: 11.1125 mm; Visibilité 1: no; Visibilité 2: yes
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 371.408 mm
Cotes - Diamètre extérieur du raccord 1: 28.575 mm; Diamètre extérieur du raccord 2: 22.225 mm; Diamètre nominal 1: 25 mm; Diamètre nominal 2: 20 mm; Hauteur de décalage: 12.5; Largeur de décalage: 12.5; Longueur: 7.14375 mm; Rayon nominal 1: 12.5 mm; Rayon nominal 2: 10 mm; Surface: 0.000934648 m2; Taille: 25 mmø-20 mmø; Taille de la coche 1: 11.43 mm; Taille de la coche 2: 8.89 mm; Taille maximale: 25 mm; Taille minimale: 20 mm; Volume: 0.00000362261 m3
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 03_PLB
Génie climatique - Type de système: 2.Eau Froide Sanitaire; Abréviation du système: EF; Classification du système: Eau froide sanitaire; Nom du système: EF 1
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 25 mmø-20 mmø
Group: EF 1

# IfcFlowFitting: AI_Raccord Canalisation_Piquage generique:standard (7)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de canalisation; Nom de la famille: AI_Raccord Canalisation_Piquage generique
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: standard; Sous-projet: Famille : Raccords de canalisation : AI_Raccord Canalisation_Piquage generique
Pset_DistributionFlowElementCommon - Reference: standard; sets with these values: 2
Autre - Famille: AI_Raccord Canalisation_Piquage generique; Famille et type: AI_Raccord Canalisation_Piquage generique: standard; ID du type: 805943; Type: standard
Contraintes - Niveau: RDC; Élévation par rapport au niveau: 350.108 mm
Cotes - diametre: 20 mm; Longueur de piquage: 20; Longueur de piquage fixe: 0; Projection de la longueur de piquage: 6.096; rayon: 10 mm; Surface: 0.00144805 m2; Taille: 20 mmø-20 mmø; Taille maximale: 20 mm; Taille minimale: 20 mm; Volume: 0.00000819789 m3
Graphismes - Utiliser l'échelle d'annotations: yes
Données d'identification - Sous-projet: 03_PLB
Génie climatique - Type de système: 2.Eau Froide Sanitaire; Abréviation du système: EF; Classification du système: Eau froide sanitaire; Nom du système: EF 1
Phase de construction - Phase de création: Nouvelle construction
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 20 mmø-20 mmø
Group: EF 1
Name (AI_Raccord Canalisation_Piquage generique:standard:...)
1225855
1225891
1225924
1225957
1226001
1226044
1226076

# IfcFlowFitting: AI_Raccord cdc_Coude desencdant:standaard (27)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de chemins de câbles; Nom de la famille: AI_Raccord cdc_Coude desencdant
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: standaard; Numéro OmniClass: 23.80.30.17.17; Sous-projet: Famille : Raccords de chemins de câbles : AI_Raccord cdc_Coude desencdant; Titre OmniClass: Cable Trays and Horizontal Racks
Pset_DistributionFlowElementCommon - Reference: standaard; sets with these values: 2
Autre - Courbure ou raccord: Raccord; Famille: AI_Raccord cdc_Coude desencdant; Famille et type: AI_Raccord cdc_Coude desencdant: standaard; ID du type: 804277; Type: standaard
Cotes - Epaisseur: 2.54 mm; Tray Length: 1 mm
Graphismes - Utiliser l'échelle d'annotations: no
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Raccord cdc_Coude desencdant:standaard:...) | Center to End (mm) | Niveau | Élévation par rapport au niveau (mm) | Angle (deg) | Radius (mm) | Rayon de courbure (mm) | Taille | Tray Height (mm) | Tray Width (mm) | Volume (m3) | Type de service
863289 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
863337 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
905831 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | CF
905854 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
906042 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
906066 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | CF
906403 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
906429 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | CF
906450 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | CF
906481 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | cfa
906681 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000316092 | CF
906711 | 131 | RDC | 2470 | 90 | 130 | 130 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.00247442 | CF
924238 | 131 | RDC | 2857 | 90 | 130 | 130 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.00247442 | cfa
1156742 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1156808 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1157591 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1157597 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1158032 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | cfa
1158038 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | cfa
1159449 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | cfa
1159517 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | cfa
1177291 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1177445 | 13.8406 | RDC | 2857 | 45 | 130 | 31 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000158046 | CF
1211019 | 22.1249 | R-1 | 2517.76 | 45 | 150 | 51 | 200 mmx100 mmø-200 mmx100 mmø | 100 | 200 | 0.000841069 | CF
1223212 | 22.1249 | R-1 | 2517.76 | 45 | 150 | 51 | 200 mmx100 mmø-200 mmx100 mmø | 100 | 200 | 0.000841069 | CF
1227953 | 22.1249 | R-1 | 2517.76 | 45 | 150 | 51 | 200 mmx100 mmø-200 mmx100 mmø | 100 | 200 | 0.000841069 | CF
1227962 | 151 | R-1 | 2350 | 90 | 150 | 150 | 200 mmx100 mmø-200 mmx100 mmø | 100 | 200 | 0.00475236 | CF

# IfcFlowFitting: AI_Raccord cdc_Coude horizontal rayon court:standaard (20)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de chemins de câbles; Nom de la famille: AI_Raccord cdc_Coude horizontal rayon court
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: standaard; Numéro OmniClass: 23.80.30.17.17; Sous-projet: Famille : Raccords de chemins de câbles : AI_Raccord cdc_Coude horizontal rayon court; Titre OmniClass: Cable Trays and Horizontal Racks
Pset_DistributionFlowElementCommon - Reference: standaard; sets with these values: 2
Autre - Courbure ou raccord: Raccord; Type: standaard; Famille: AI_Raccord cdc_Coude horizontal rayon court; Famille et type: AI_Raccord cdc_Coude horizontal rayon court: standaard; ID du type: 804576
Cotes - Epaisseur: 2.54 mm; Radius: 100 mm; Tray Length: 1 mm
Graphismes - Utiliser l'échelle d'annotations: no
Données d'identification - Sous-projet: 02_ELE
Phase de construction - Phase de création: Nouvelle construction
Name (AI_Raccord cdc_Coude horizontal rayon court:standaard:...) | Bend Radius Label (mm) | Center to End (mm) | Niveau | Élévation par rapport au niveau (mm) | Angle (deg) | Rayon de courbure (mm) | Taille | Tray Height (mm) | Tray Width (mm) | Volume (m3) | Type de service
863379 | 220 | 96.4528 | RDC | 2857 | 77.0003 | 120 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.00195921 | cfa
906402 | 300 | 201 | RDC | 2857 | 90 | 200 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.0037939 | cfa
906428 | 300 | 201 | RDC | 2857 | 90 | 200 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.0037939 | CF
906458 | 220 | 14.672 | RDC | 2703.71 | 12.9997 | 120 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000350718 | CF
906485 | 220 | 14.672 | RDC | 2703.71 | 12.9997 | 120 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.000350718 | cfa
925830 | 220 | 96.4528 | RDC | 2470 | 77.0003 | 120 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.00195921 | CF
925831 | 220 | 96.4528 | RDC | 2470 | 77.0003 | 120 | 200 mmx60 mmø-200 mmx60 mmø | 60 | 200 | 0.00195921 | CF
1156860 | 200 | 151 | RDC | 2857 | 90 | 150 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.00142571 | CF
1156875 | 200 | 151 | RDC | 2857 | 90 | 150 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.00142571 | cfa
1157599 | 200 | 151 | RDC | 2857 | 90 | 150 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.00142571 | CF
1157600 | 200 | 151 | RDC | 2857 | 90 | 150 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.00142571 | cfa
1158040 | 200 | 151 | RDC | 2857 | 90 | 150 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.00142571 | cfa
1158041 | 200 | 151 | RDC | 2857 | 90 | 150 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.00142571 | CF
1158903 | 200 | 151 | RDC | 2857 | 90 | 150 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.00142571 | cfa
1158904 | 200 | 151 | RDC | 2857 | 90 | 150 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.00142571 | CF
1159339 | 120 | 8.97561 | RDC | 2857 | 13.0002 | 70 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000107296 | cfa
1159360 | 120 | 8.9755 | RDC | 2857 | 13 | 70 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.000107295 | CF
1177299 | 200 | 151 | RDC | 2857 | 90 | 150 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.00142571 | CF
1177300 | 200 | 151 | RDC | 2857 | 90 | 150 | 100 mmx60 mmø-100 mmx60 mmø | 60 | 100 | 0.00142571 | cfa
1211018 | 300 | 201 | R-1 | 2517.76 | 90 | 200 | 200 mmx100 mmø-200 mmx100 mmø | 100 | 200 | 0.00632317 | CF

# IfcFlowFitting: AI_Raccord cdc_Coude montant:standaard (27)
In: RDC
Type - Material: <Unnamed>
Type - Autre - Catégorie: Raccords de chemins de câbles; Nom de la famille: AI_Raccord cdc_Coude montant
Type - Contraintes - Elévation par défaut: 0 mm
Type - Données d'identification - Nom du type: standaard; Numéro OmniClass: 23.80.30.17.17; Sous-projet: Famille : Raccords de chemins de câbles : AI_Raccord cdc_Coude montant; Titre OmniClass: Cable Trays and Horizontal Racks
Pset_DistributionFlowElementCommon - Reference: standaard; sets with these values: 2
Autre - Courbure ou raccord: Raccord; Type: standaard; Famille: AI_Raccord cdc_Coude montant; Famille et type: AI_Raccord cdc_Coude montant: standaard; ID du type: 804279
Cotes - Epaisseur: 2.54 mm; Tray Length: 1 mm
Graphismes - Utiliser l'échelle d'annotations: no
Données d'identification - Sous-projet: 02_ELE
